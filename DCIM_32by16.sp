** DCIM Bonus **
** Environment setting **

.include 'testcase_bonus.sp'

**********************************************
*** Don't modify the pin name in this file ***
**********************************************

.ic V(Xdcim.Xcim1.W10)=0.0v
.ic V(Xdcim.Xcim1.W11)=0.0v
.ic V(Xdcim.Xcim1.W12)=0.0v
.ic V(Xdcim.Xcim1.W13)=0.0v
.ic V(Xdcim.Xcim1.W20)=0.0v
.ic V(Xdcim.Xcim1.W21)=0.0v
.ic V(Xdcim.Xcim1.W22)=0.0v
.ic V(Xdcim.Xcim1.W23)=0.0v
.ic V(Xdcim.Xcim1.W30)=0.0v
.ic V(Xdcim.Xcim1.W31)=0.0v
.ic V(Xdcim.Xcim1.W32)=0.0v
.ic V(Xdcim.Xcim1.W33)=0.0v
.ic V(Xdcim.Xcim1.W40)=0.0v
.ic V(Xdcim.Xcim1.W41)=0.0v
.ic V(Xdcim.Xcim1.W42)=0.0v
.ic V(Xdcim.Xcim1.W43)=0.0v
.ic V(Xdcim.Xcim1.W50)=0.0v
.ic V(Xdcim.Xcim1.W51)=0.0v
.ic V(Xdcim.Xcim1.W52)=0.0v
.ic V(Xdcim.Xcim1.W53)=0.0v
.ic V(Xdcim.Xcim1.W60)=0.0v
.ic V(Xdcim.Xcim1.W61)=0.0v
.ic V(Xdcim.Xcim1.W62)=0.0v
.ic V(Xdcim.Xcim1.W63)=0.0v
.ic V(Xdcim.Xcim1.W70)=0.0v
.ic V(Xdcim.Xcim1.W71)=0.0v
.ic V(Xdcim.Xcim1.W72)=0.0v
.ic V(Xdcim.Xcim1.W73)=0.0v
.ic V(Xdcim.Xcim1.W80)=0.0v
.ic V(Xdcim.Xcim1.W81)=0.0v
.ic V(Xdcim.Xcim1.W82)=0.0v
.ic V(Xdcim.Xcim1.W83)=0.0v
.ic V(Xdcim.Xcim1.W90)=0.0v
.ic V(Xdcim.Xcim1.W91)=0.0v
.ic V(Xdcim.Xcim1.W92)=0.0v
.ic V(Xdcim.Xcim1.W93)=0.0v
.ic V(Xdcim.Xcim1.W100)=0.0v
.ic V(Xdcim.Xcim1.W101)=0.0v
.ic V(Xdcim.Xcim1.W102)=0.0v
.ic V(Xdcim.Xcim1.W103)=0.0v
.ic V(Xdcim.Xcim1.W110)=0.0v
.ic V(Xdcim.Xcim1.W111)=0.0v
.ic V(Xdcim.Xcim1.W112)=0.0v
.ic V(Xdcim.Xcim1.W113)=0.0v
.ic V(Xdcim.Xcim1.W120)=0.0v
.ic V(Xdcim.Xcim1.W121)=0.0v
.ic V(Xdcim.Xcim1.W122)=0.0v
.ic V(Xdcim.Xcim1.W123)=0.0v
.ic V(Xdcim.Xcim1.W130)=0.0v
.ic V(Xdcim.Xcim1.W131)=0.0v
.ic V(Xdcim.Xcim1.W132)=0.0v
.ic V(Xdcim.Xcim1.W133)=0.0v
.ic V(Xdcim.Xcim1.W140)=0.0v
.ic V(Xdcim.Xcim1.W141)=0.0v
.ic V(Xdcim.Xcim1.W142)=0.0v
.ic V(Xdcim.Xcim1.W143)=0.0v
.ic V(Xdcim.Xcim1.W150)=0.0v
.ic V(Xdcim.Xcim1.W151)=0.0v
.ic V(Xdcim.Xcim1.W152)=0.0v
.ic V(Xdcim.Xcim1.W153)=0.0v
.ic V(Xdcim.Xcim1.W160)=0.0v
.ic V(Xdcim.Xcim1.W161)=0.0v
.ic V(Xdcim.Xcim1.W162)=0.0v
.ic V(Xdcim.Xcim1.W163)=0.0v
.ic V(Xdcim.Xcim1.W170)=0.0v
.ic V(Xdcim.Xcim1.W171)=0.0v
.ic V(Xdcim.Xcim1.W172)=0.0v
.ic V(Xdcim.Xcim1.W173)=0.0v
.ic V(Xdcim.Xcim1.W180)=0.0v
.ic V(Xdcim.Xcim1.W181)=0.0v
.ic V(Xdcim.Xcim1.W182)=0.0v
.ic V(Xdcim.Xcim1.W183)=0.0v
.ic V(Xdcim.Xcim1.W190)=0.0v
.ic V(Xdcim.Xcim1.W191)=0.0v
.ic V(Xdcim.Xcim1.W192)=0.0v
.ic V(Xdcim.Xcim1.W193)=0.0v
.ic V(Xdcim.Xcim1.W200)=0.0v
.ic V(Xdcim.Xcim1.W201)=0.0v
.ic V(Xdcim.Xcim1.W202)=0.0v
.ic V(Xdcim.Xcim1.W203)=0.0v
.ic V(Xdcim.Xcim1.W210)=0.0v
.ic V(Xdcim.Xcim1.W211)=0.0v
.ic V(Xdcim.Xcim1.W212)=0.0v
.ic V(Xdcim.Xcim1.W213)=0.0v
.ic V(Xdcim.Xcim1.W220)=0.0v
.ic V(Xdcim.Xcim1.W221)=0.0v
.ic V(Xdcim.Xcim1.W222)=0.0v
.ic V(Xdcim.Xcim1.W223)=0.0v
.ic V(Xdcim.Xcim1.W230)=0.0v
.ic V(Xdcim.Xcim1.W231)=0.0v
.ic V(Xdcim.Xcim1.W232)=0.0v
.ic V(Xdcim.Xcim1.W233)=0.0v
.ic V(Xdcim.Xcim1.W240)=0.0v
.ic V(Xdcim.Xcim1.W241)=0.0v
.ic V(Xdcim.Xcim1.W242)=0.0v
.ic V(Xdcim.Xcim1.W243)=0.0v
.ic V(Xdcim.Xcim1.W250)=0.0v
.ic V(Xdcim.Xcim1.W251)=0.0v
.ic V(Xdcim.Xcim1.W252)=0.0v
.ic V(Xdcim.Xcim1.W253)=0.0v
.ic V(Xdcim.Xcim1.W260)=0.0v
.ic V(Xdcim.Xcim1.W261)=0.0v
.ic V(Xdcim.Xcim1.W262)=0.0v
.ic V(Xdcim.Xcim1.W263)=0.0v
.ic V(Xdcim.Xcim1.W270)=0.0v
.ic V(Xdcim.Xcim1.W271)=0.0v
.ic V(Xdcim.Xcim1.W272)=0.0v
.ic V(Xdcim.Xcim1.W273)=0.0v
.ic V(Xdcim.Xcim1.W280)=0.0v
.ic V(Xdcim.Xcim1.W281)=0.0v
.ic V(Xdcim.Xcim1.W282)=0.0v
.ic V(Xdcim.Xcim1.W283)=0.0v
.ic V(Xdcim.Xcim1.W290)=0.0v
.ic V(Xdcim.Xcim1.W291)=0.0v
.ic V(Xdcim.Xcim1.W292)=0.0v
.ic V(Xdcim.Xcim1.W293)=0.0v
.ic V(Xdcim.Xcim1.W300)=0.0v
.ic V(Xdcim.Xcim1.W301)=0.0v
.ic V(Xdcim.Xcim1.W302)=0.0v
.ic V(Xdcim.Xcim1.W303)=0.0v
.ic V(Xdcim.Xcim1.W310)=0.0v
.ic V(Xdcim.Xcim1.W311)=0.0v
.ic V(Xdcim.Xcim1.W312)=0.0v
.ic V(Xdcim.Xcim1.W313)=0.0v
.ic V(Xdcim.Xcim1.W320)=0.0v
.ic V(Xdcim.Xcim1.W321)=0.0v
.ic V(Xdcim.Xcim1.W322)=0.0v
.ic V(Xdcim.Xcim1.W323)=0.0v
.ic V(Xdcim.Xcim2.W10)=1.8v
.ic V(Xdcim.Xcim2.W11)=0.0v
.ic V(Xdcim.Xcim2.W12)=0.0v
.ic V(Xdcim.Xcim2.W13)=0.0v
.ic V(Xdcim.Xcim2.W20)=1.8v
.ic V(Xdcim.Xcim2.W21)=0.0v
.ic V(Xdcim.Xcim2.W22)=0.0v
.ic V(Xdcim.Xcim2.W23)=0.0v
.ic V(Xdcim.Xcim2.W30)=1.8v
.ic V(Xdcim.Xcim2.W31)=0.0v
.ic V(Xdcim.Xcim2.W32)=0.0v
.ic V(Xdcim.Xcim2.W33)=0.0v
.ic V(Xdcim.Xcim2.W40)=1.8v
.ic V(Xdcim.Xcim2.W41)=0.0v
.ic V(Xdcim.Xcim2.W42)=0.0v
.ic V(Xdcim.Xcim2.W43)=0.0v
.ic V(Xdcim.Xcim2.W50)=1.8v
.ic V(Xdcim.Xcim2.W51)=0.0v
.ic V(Xdcim.Xcim2.W52)=0.0v
.ic V(Xdcim.Xcim2.W53)=0.0v
.ic V(Xdcim.Xcim2.W60)=1.8v
.ic V(Xdcim.Xcim2.W61)=0.0v
.ic V(Xdcim.Xcim2.W62)=0.0v
.ic V(Xdcim.Xcim2.W63)=0.0v
.ic V(Xdcim.Xcim2.W70)=1.8v
.ic V(Xdcim.Xcim2.W71)=0.0v
.ic V(Xdcim.Xcim2.W72)=0.0v
.ic V(Xdcim.Xcim2.W73)=0.0v
.ic V(Xdcim.Xcim2.W80)=1.8v
.ic V(Xdcim.Xcim2.W81)=0.0v
.ic V(Xdcim.Xcim2.W82)=0.0v
.ic V(Xdcim.Xcim2.W83)=0.0v
.ic V(Xdcim.Xcim2.W90)=1.8v
.ic V(Xdcim.Xcim2.W91)=0.0v
.ic V(Xdcim.Xcim2.W92)=0.0v
.ic V(Xdcim.Xcim2.W93)=0.0v
.ic V(Xdcim.Xcim2.W100)=1.8v
.ic V(Xdcim.Xcim2.W101)=0.0v
.ic V(Xdcim.Xcim2.W102)=0.0v
.ic V(Xdcim.Xcim2.W103)=0.0v
.ic V(Xdcim.Xcim2.W110)=1.8v
.ic V(Xdcim.Xcim2.W111)=0.0v
.ic V(Xdcim.Xcim2.W112)=0.0v
.ic V(Xdcim.Xcim2.W113)=0.0v
.ic V(Xdcim.Xcim2.W120)=1.8v
.ic V(Xdcim.Xcim2.W121)=0.0v
.ic V(Xdcim.Xcim2.W122)=0.0v
.ic V(Xdcim.Xcim2.W123)=0.0v
.ic V(Xdcim.Xcim2.W130)=1.8v
.ic V(Xdcim.Xcim2.W131)=0.0v
.ic V(Xdcim.Xcim2.W132)=0.0v
.ic V(Xdcim.Xcim2.W133)=0.0v
.ic V(Xdcim.Xcim2.W140)=1.8v
.ic V(Xdcim.Xcim2.W141)=0.0v
.ic V(Xdcim.Xcim2.W142)=0.0v
.ic V(Xdcim.Xcim2.W143)=0.0v
.ic V(Xdcim.Xcim2.W150)=1.8v
.ic V(Xdcim.Xcim2.W151)=0.0v
.ic V(Xdcim.Xcim2.W152)=0.0v
.ic V(Xdcim.Xcim2.W153)=0.0v
.ic V(Xdcim.Xcim2.W160)=1.8v
.ic V(Xdcim.Xcim2.W161)=0.0v
.ic V(Xdcim.Xcim2.W162)=0.0v
.ic V(Xdcim.Xcim2.W163)=0.0v
.ic V(Xdcim.Xcim2.W170)=1.8v
.ic V(Xdcim.Xcim2.W171)=0.0v
.ic V(Xdcim.Xcim2.W172)=0.0v
.ic V(Xdcim.Xcim2.W173)=0.0v
.ic V(Xdcim.Xcim2.W180)=1.8v
.ic V(Xdcim.Xcim2.W181)=0.0v
.ic V(Xdcim.Xcim2.W182)=0.0v
.ic V(Xdcim.Xcim2.W183)=0.0v
.ic V(Xdcim.Xcim2.W190)=1.8v
.ic V(Xdcim.Xcim2.W191)=0.0v
.ic V(Xdcim.Xcim2.W192)=0.0v
.ic V(Xdcim.Xcim2.W193)=0.0v
.ic V(Xdcim.Xcim2.W200)=1.8v
.ic V(Xdcim.Xcim2.W201)=0.0v
.ic V(Xdcim.Xcim2.W202)=0.0v
.ic V(Xdcim.Xcim2.W203)=0.0v
.ic V(Xdcim.Xcim2.W210)=1.8v
.ic V(Xdcim.Xcim2.W211)=0.0v
.ic V(Xdcim.Xcim2.W212)=0.0v
.ic V(Xdcim.Xcim2.W213)=0.0v
.ic V(Xdcim.Xcim2.W220)=1.8v
.ic V(Xdcim.Xcim2.W221)=0.0v
.ic V(Xdcim.Xcim2.W222)=0.0v
.ic V(Xdcim.Xcim2.W223)=0.0v
.ic V(Xdcim.Xcim2.W230)=1.8v
.ic V(Xdcim.Xcim2.W231)=0.0v
.ic V(Xdcim.Xcim2.W232)=0.0v
.ic V(Xdcim.Xcim2.W233)=0.0v
.ic V(Xdcim.Xcim2.W240)=1.8v
.ic V(Xdcim.Xcim2.W241)=0.0v
.ic V(Xdcim.Xcim2.W242)=0.0v
.ic V(Xdcim.Xcim2.W243)=0.0v
.ic V(Xdcim.Xcim2.W250)=1.8v
.ic V(Xdcim.Xcim2.W251)=0.0v
.ic V(Xdcim.Xcim2.W252)=0.0v
.ic V(Xdcim.Xcim2.W253)=0.0v
.ic V(Xdcim.Xcim2.W260)=1.8v
.ic V(Xdcim.Xcim2.W261)=0.0v
.ic V(Xdcim.Xcim2.W262)=0.0v
.ic V(Xdcim.Xcim2.W263)=0.0v
.ic V(Xdcim.Xcim2.W270)=1.8v
.ic V(Xdcim.Xcim2.W271)=0.0v
.ic V(Xdcim.Xcim2.W272)=0.0v
.ic V(Xdcim.Xcim2.W273)=0.0v
.ic V(Xdcim.Xcim2.W280)=1.8v
.ic V(Xdcim.Xcim2.W281)=0.0v
.ic V(Xdcim.Xcim2.W282)=0.0v
.ic V(Xdcim.Xcim2.W283)=0.0v
.ic V(Xdcim.Xcim2.W290)=1.8v
.ic V(Xdcim.Xcim2.W291)=0.0v
.ic V(Xdcim.Xcim2.W292)=0.0v
.ic V(Xdcim.Xcim2.W293)=0.0v
.ic V(Xdcim.Xcim2.W300)=1.8v
.ic V(Xdcim.Xcim2.W301)=0.0v
.ic V(Xdcim.Xcim2.W302)=0.0v
.ic V(Xdcim.Xcim2.W303)=0.0v
.ic V(Xdcim.Xcim2.W310)=1.8v
.ic V(Xdcim.Xcim2.W311)=0.0v
.ic V(Xdcim.Xcim2.W312)=0.0v
.ic V(Xdcim.Xcim2.W313)=0.0v
.ic V(Xdcim.Xcim2.W320)=1.8v
.ic V(Xdcim.Xcim2.W321)=0.0v
.ic V(Xdcim.Xcim2.W322)=0.0v
.ic V(Xdcim.Xcim2.W323)=0.0v
.ic V(Xdcim.Xcim3.W10)=0.0v
.ic V(Xdcim.Xcim3.W11)=1.8v
.ic V(Xdcim.Xcim3.W12)=0.0v
.ic V(Xdcim.Xcim3.W13)=0.0v
.ic V(Xdcim.Xcim3.W20)=0.0v
.ic V(Xdcim.Xcim3.W21)=1.8v
.ic V(Xdcim.Xcim3.W22)=0.0v
.ic V(Xdcim.Xcim3.W23)=0.0v
.ic V(Xdcim.Xcim3.W30)=0.0v
.ic V(Xdcim.Xcim3.W31)=1.8v
.ic V(Xdcim.Xcim3.W32)=0.0v
.ic V(Xdcim.Xcim3.W33)=0.0v
.ic V(Xdcim.Xcim3.W40)=0.0v
.ic V(Xdcim.Xcim3.W41)=1.8v
.ic V(Xdcim.Xcim3.W42)=0.0v
.ic V(Xdcim.Xcim3.W43)=0.0v
.ic V(Xdcim.Xcim3.W50)=0.0v
.ic V(Xdcim.Xcim3.W51)=1.8v
.ic V(Xdcim.Xcim3.W52)=0.0v
.ic V(Xdcim.Xcim3.W53)=0.0v
.ic V(Xdcim.Xcim3.W60)=0.0v
.ic V(Xdcim.Xcim3.W61)=1.8v
.ic V(Xdcim.Xcim3.W62)=0.0v
.ic V(Xdcim.Xcim3.W63)=0.0v
.ic V(Xdcim.Xcim3.W70)=0.0v
.ic V(Xdcim.Xcim3.W71)=1.8v
.ic V(Xdcim.Xcim3.W72)=0.0v
.ic V(Xdcim.Xcim3.W73)=0.0v
.ic V(Xdcim.Xcim3.W80)=0.0v
.ic V(Xdcim.Xcim3.W81)=1.8v
.ic V(Xdcim.Xcim3.W82)=0.0v
.ic V(Xdcim.Xcim3.W83)=0.0v
.ic V(Xdcim.Xcim3.W90)=0.0v
.ic V(Xdcim.Xcim3.W91)=1.8v
.ic V(Xdcim.Xcim3.W92)=0.0v
.ic V(Xdcim.Xcim3.W93)=0.0v
.ic V(Xdcim.Xcim3.W100)=0.0v
.ic V(Xdcim.Xcim3.W101)=1.8v
.ic V(Xdcim.Xcim3.W102)=0.0v
.ic V(Xdcim.Xcim3.W103)=0.0v
.ic V(Xdcim.Xcim3.W110)=0.0v
.ic V(Xdcim.Xcim3.W111)=1.8v
.ic V(Xdcim.Xcim3.W112)=0.0v
.ic V(Xdcim.Xcim3.W113)=0.0v
.ic V(Xdcim.Xcim3.W120)=0.0v
.ic V(Xdcim.Xcim3.W121)=1.8v
.ic V(Xdcim.Xcim3.W122)=0.0v
.ic V(Xdcim.Xcim3.W123)=0.0v
.ic V(Xdcim.Xcim3.W130)=0.0v
.ic V(Xdcim.Xcim3.W131)=1.8v
.ic V(Xdcim.Xcim3.W132)=0.0v
.ic V(Xdcim.Xcim3.W133)=0.0v
.ic V(Xdcim.Xcim3.W140)=0.0v
.ic V(Xdcim.Xcim3.W141)=1.8v
.ic V(Xdcim.Xcim3.W142)=0.0v
.ic V(Xdcim.Xcim3.W143)=0.0v
.ic V(Xdcim.Xcim3.W150)=0.0v
.ic V(Xdcim.Xcim3.W151)=1.8v
.ic V(Xdcim.Xcim3.W152)=0.0v
.ic V(Xdcim.Xcim3.W153)=0.0v
.ic V(Xdcim.Xcim3.W160)=0.0v
.ic V(Xdcim.Xcim3.W161)=1.8v
.ic V(Xdcim.Xcim3.W162)=0.0v
.ic V(Xdcim.Xcim3.W163)=0.0v
.ic V(Xdcim.Xcim3.W170)=0.0v
.ic V(Xdcim.Xcim3.W171)=1.8v
.ic V(Xdcim.Xcim3.W172)=0.0v
.ic V(Xdcim.Xcim3.W173)=0.0v
.ic V(Xdcim.Xcim3.W180)=0.0v
.ic V(Xdcim.Xcim3.W181)=1.8v
.ic V(Xdcim.Xcim3.W182)=0.0v
.ic V(Xdcim.Xcim3.W183)=0.0v
.ic V(Xdcim.Xcim3.W190)=0.0v
.ic V(Xdcim.Xcim3.W191)=1.8v
.ic V(Xdcim.Xcim3.W192)=0.0v
.ic V(Xdcim.Xcim3.W193)=0.0v
.ic V(Xdcim.Xcim3.W200)=0.0v
.ic V(Xdcim.Xcim3.W201)=1.8v
.ic V(Xdcim.Xcim3.W202)=0.0v
.ic V(Xdcim.Xcim3.W203)=0.0v
.ic V(Xdcim.Xcim3.W210)=0.0v
.ic V(Xdcim.Xcim3.W211)=1.8v
.ic V(Xdcim.Xcim3.W212)=0.0v
.ic V(Xdcim.Xcim3.W213)=0.0v
.ic V(Xdcim.Xcim3.W220)=0.0v
.ic V(Xdcim.Xcim3.W221)=1.8v
.ic V(Xdcim.Xcim3.W222)=0.0v
.ic V(Xdcim.Xcim3.W223)=0.0v
.ic V(Xdcim.Xcim3.W230)=0.0v
.ic V(Xdcim.Xcim3.W231)=1.8v
.ic V(Xdcim.Xcim3.W232)=0.0v
.ic V(Xdcim.Xcim3.W233)=0.0v
.ic V(Xdcim.Xcim3.W240)=0.0v
.ic V(Xdcim.Xcim3.W241)=1.8v
.ic V(Xdcim.Xcim3.W242)=0.0v
.ic V(Xdcim.Xcim3.W243)=0.0v
.ic V(Xdcim.Xcim3.W250)=0.0v
.ic V(Xdcim.Xcim3.W251)=1.8v
.ic V(Xdcim.Xcim3.W252)=0.0v
.ic V(Xdcim.Xcim3.W253)=0.0v
.ic V(Xdcim.Xcim3.W260)=0.0v
.ic V(Xdcim.Xcim3.W261)=1.8v
.ic V(Xdcim.Xcim3.W262)=0.0v
.ic V(Xdcim.Xcim3.W263)=0.0v
.ic V(Xdcim.Xcim3.W270)=0.0v
.ic V(Xdcim.Xcim3.W271)=1.8v
.ic V(Xdcim.Xcim3.W272)=0.0v
.ic V(Xdcim.Xcim3.W273)=0.0v
.ic V(Xdcim.Xcim3.W280)=0.0v
.ic V(Xdcim.Xcim3.W281)=1.8v
.ic V(Xdcim.Xcim3.W282)=0.0v
.ic V(Xdcim.Xcim3.W283)=0.0v
.ic V(Xdcim.Xcim3.W290)=0.0v
.ic V(Xdcim.Xcim3.W291)=1.8v
.ic V(Xdcim.Xcim3.W292)=0.0v
.ic V(Xdcim.Xcim3.W293)=0.0v
.ic V(Xdcim.Xcim3.W300)=0.0v
.ic V(Xdcim.Xcim3.W301)=1.8v
.ic V(Xdcim.Xcim3.W302)=0.0v
.ic V(Xdcim.Xcim3.W303)=0.0v
.ic V(Xdcim.Xcim3.W310)=0.0v
.ic V(Xdcim.Xcim3.W311)=1.8v
.ic V(Xdcim.Xcim3.W312)=0.0v
.ic V(Xdcim.Xcim3.W313)=0.0v
.ic V(Xdcim.Xcim3.W320)=0.0v
.ic V(Xdcim.Xcim3.W321)=1.8v
.ic V(Xdcim.Xcim3.W322)=0.0v
.ic V(Xdcim.Xcim3.W323)=0.0v
.ic V(Xdcim.Xcim4.W10)=1.8v
.ic V(Xdcim.Xcim4.W11)=1.8v
.ic V(Xdcim.Xcim4.W12)=0.0v
.ic V(Xdcim.Xcim4.W13)=0.0v
.ic V(Xdcim.Xcim4.W20)=1.8v
.ic V(Xdcim.Xcim4.W21)=1.8v
.ic V(Xdcim.Xcim4.W22)=0.0v
.ic V(Xdcim.Xcim4.W23)=0.0v
.ic V(Xdcim.Xcim4.W30)=1.8v
.ic V(Xdcim.Xcim4.W31)=1.8v
.ic V(Xdcim.Xcim4.W32)=0.0v
.ic V(Xdcim.Xcim4.W33)=0.0v
.ic V(Xdcim.Xcim4.W40)=1.8v
.ic V(Xdcim.Xcim4.W41)=1.8v
.ic V(Xdcim.Xcim4.W42)=0.0v
.ic V(Xdcim.Xcim4.W43)=0.0v
.ic V(Xdcim.Xcim4.W50)=1.8v
.ic V(Xdcim.Xcim4.W51)=1.8v
.ic V(Xdcim.Xcim4.W52)=0.0v
.ic V(Xdcim.Xcim4.W53)=0.0v
.ic V(Xdcim.Xcim4.W60)=1.8v
.ic V(Xdcim.Xcim4.W61)=1.8v
.ic V(Xdcim.Xcim4.W62)=0.0v
.ic V(Xdcim.Xcim4.W63)=0.0v
.ic V(Xdcim.Xcim4.W70)=1.8v
.ic V(Xdcim.Xcim4.W71)=1.8v
.ic V(Xdcim.Xcim4.W72)=0.0v
.ic V(Xdcim.Xcim4.W73)=0.0v
.ic V(Xdcim.Xcim4.W80)=1.8v
.ic V(Xdcim.Xcim4.W81)=1.8v
.ic V(Xdcim.Xcim4.W82)=0.0v
.ic V(Xdcim.Xcim4.W83)=0.0v
.ic V(Xdcim.Xcim4.W90)=1.8v
.ic V(Xdcim.Xcim4.W91)=1.8v
.ic V(Xdcim.Xcim4.W92)=0.0v
.ic V(Xdcim.Xcim4.W93)=0.0v
.ic V(Xdcim.Xcim4.W100)=1.8v
.ic V(Xdcim.Xcim4.W101)=1.8v
.ic V(Xdcim.Xcim4.W102)=0.0v
.ic V(Xdcim.Xcim4.W103)=0.0v
.ic V(Xdcim.Xcim4.W110)=1.8v
.ic V(Xdcim.Xcim4.W111)=1.8v
.ic V(Xdcim.Xcim4.W112)=0.0v
.ic V(Xdcim.Xcim4.W113)=0.0v
.ic V(Xdcim.Xcim4.W120)=1.8v
.ic V(Xdcim.Xcim4.W121)=1.8v
.ic V(Xdcim.Xcim4.W122)=0.0v
.ic V(Xdcim.Xcim4.W123)=0.0v
.ic V(Xdcim.Xcim4.W130)=1.8v
.ic V(Xdcim.Xcim4.W131)=1.8v
.ic V(Xdcim.Xcim4.W132)=0.0v
.ic V(Xdcim.Xcim4.W133)=0.0v
.ic V(Xdcim.Xcim4.W140)=1.8v
.ic V(Xdcim.Xcim4.W141)=1.8v
.ic V(Xdcim.Xcim4.W142)=0.0v
.ic V(Xdcim.Xcim4.W143)=0.0v
.ic V(Xdcim.Xcim4.W150)=1.8v
.ic V(Xdcim.Xcim4.W151)=1.8v
.ic V(Xdcim.Xcim4.W152)=0.0v
.ic V(Xdcim.Xcim4.W153)=0.0v
.ic V(Xdcim.Xcim4.W160)=1.8v
.ic V(Xdcim.Xcim4.W161)=1.8v
.ic V(Xdcim.Xcim4.W162)=0.0v
.ic V(Xdcim.Xcim4.W163)=0.0v
.ic V(Xdcim.Xcim4.W170)=1.8v
.ic V(Xdcim.Xcim4.W171)=1.8v
.ic V(Xdcim.Xcim4.W172)=0.0v
.ic V(Xdcim.Xcim4.W173)=0.0v
.ic V(Xdcim.Xcim4.W180)=1.8v
.ic V(Xdcim.Xcim4.W181)=1.8v
.ic V(Xdcim.Xcim4.W182)=0.0v
.ic V(Xdcim.Xcim4.W183)=0.0v
.ic V(Xdcim.Xcim4.W190)=1.8v
.ic V(Xdcim.Xcim4.W191)=1.8v
.ic V(Xdcim.Xcim4.W192)=0.0v
.ic V(Xdcim.Xcim4.W193)=0.0v
.ic V(Xdcim.Xcim4.W200)=1.8v
.ic V(Xdcim.Xcim4.W201)=1.8v
.ic V(Xdcim.Xcim4.W202)=0.0v
.ic V(Xdcim.Xcim4.W203)=0.0v
.ic V(Xdcim.Xcim4.W210)=1.8v
.ic V(Xdcim.Xcim4.W211)=1.8v
.ic V(Xdcim.Xcim4.W212)=0.0v
.ic V(Xdcim.Xcim4.W213)=0.0v
.ic V(Xdcim.Xcim4.W220)=1.8v
.ic V(Xdcim.Xcim4.W221)=1.8v
.ic V(Xdcim.Xcim4.W222)=0.0v
.ic V(Xdcim.Xcim4.W223)=0.0v
.ic V(Xdcim.Xcim4.W230)=1.8v
.ic V(Xdcim.Xcim4.W231)=1.8v
.ic V(Xdcim.Xcim4.W232)=0.0v
.ic V(Xdcim.Xcim4.W233)=0.0v
.ic V(Xdcim.Xcim4.W240)=1.8v
.ic V(Xdcim.Xcim4.W241)=1.8v
.ic V(Xdcim.Xcim4.W242)=0.0v
.ic V(Xdcim.Xcim4.W243)=0.0v
.ic V(Xdcim.Xcim4.W250)=1.8v
.ic V(Xdcim.Xcim4.W251)=1.8v
.ic V(Xdcim.Xcim4.W252)=0.0v
.ic V(Xdcim.Xcim4.W253)=0.0v
.ic V(Xdcim.Xcim4.W260)=1.8v
.ic V(Xdcim.Xcim4.W261)=1.8v
.ic V(Xdcim.Xcim4.W262)=0.0v
.ic V(Xdcim.Xcim4.W263)=0.0v
.ic V(Xdcim.Xcim4.W270)=1.8v
.ic V(Xdcim.Xcim4.W271)=1.8v
.ic V(Xdcim.Xcim4.W272)=0.0v
.ic V(Xdcim.Xcim4.W273)=0.0v
.ic V(Xdcim.Xcim4.W280)=1.8v
.ic V(Xdcim.Xcim4.W281)=1.8v
.ic V(Xdcim.Xcim4.W282)=0.0v
.ic V(Xdcim.Xcim4.W283)=0.0v
.ic V(Xdcim.Xcim4.W290)=1.8v
.ic V(Xdcim.Xcim4.W291)=1.8v
.ic V(Xdcim.Xcim4.W292)=0.0v
.ic V(Xdcim.Xcim4.W293)=0.0v
.ic V(Xdcim.Xcim4.W300)=1.8v
.ic V(Xdcim.Xcim4.W301)=1.8v
.ic V(Xdcim.Xcim4.W302)=0.0v
.ic V(Xdcim.Xcim4.W303)=0.0v
.ic V(Xdcim.Xcim4.W310)=1.8v
.ic V(Xdcim.Xcim4.W311)=1.8v
.ic V(Xdcim.Xcim4.W312)=0.0v
.ic V(Xdcim.Xcim4.W313)=0.0v
.ic V(Xdcim.Xcim4.W320)=1.8v
.ic V(Xdcim.Xcim4.W321)=1.8v
.ic V(Xdcim.Xcim4.W322)=0.0v
.ic V(Xdcim.Xcim4.W323)=0.0v
.ic V(Xdcim.Xcim5.W10)=0.0v
.ic V(Xdcim.Xcim5.W11)=0.0v
.ic V(Xdcim.Xcim5.W12)=1.8v
.ic V(Xdcim.Xcim5.W13)=0.0v
.ic V(Xdcim.Xcim5.W20)=0.0v
.ic V(Xdcim.Xcim5.W21)=0.0v
.ic V(Xdcim.Xcim5.W22)=1.8v
.ic V(Xdcim.Xcim5.W23)=0.0v
.ic V(Xdcim.Xcim5.W30)=0.0v
.ic V(Xdcim.Xcim5.W31)=0.0v
.ic V(Xdcim.Xcim5.W32)=1.8v
.ic V(Xdcim.Xcim5.W33)=0.0v
.ic V(Xdcim.Xcim5.W40)=0.0v
.ic V(Xdcim.Xcim5.W41)=0.0v
.ic V(Xdcim.Xcim5.W42)=1.8v
.ic V(Xdcim.Xcim5.W43)=0.0v
.ic V(Xdcim.Xcim5.W50)=0.0v
.ic V(Xdcim.Xcim5.W51)=0.0v
.ic V(Xdcim.Xcim5.W52)=1.8v
.ic V(Xdcim.Xcim5.W53)=0.0v
.ic V(Xdcim.Xcim5.W60)=0.0v
.ic V(Xdcim.Xcim5.W61)=0.0v
.ic V(Xdcim.Xcim5.W62)=1.8v
.ic V(Xdcim.Xcim5.W63)=0.0v
.ic V(Xdcim.Xcim5.W70)=0.0v
.ic V(Xdcim.Xcim5.W71)=0.0v
.ic V(Xdcim.Xcim5.W72)=1.8v
.ic V(Xdcim.Xcim5.W73)=0.0v
.ic V(Xdcim.Xcim5.W80)=0.0v
.ic V(Xdcim.Xcim5.W81)=0.0v
.ic V(Xdcim.Xcim5.W82)=1.8v
.ic V(Xdcim.Xcim5.W83)=0.0v
.ic V(Xdcim.Xcim5.W90)=0.0v
.ic V(Xdcim.Xcim5.W91)=0.0v
.ic V(Xdcim.Xcim5.W92)=1.8v
.ic V(Xdcim.Xcim5.W93)=0.0v
.ic V(Xdcim.Xcim5.W100)=0.0v
.ic V(Xdcim.Xcim5.W101)=0.0v
.ic V(Xdcim.Xcim5.W102)=1.8v
.ic V(Xdcim.Xcim5.W103)=0.0v
.ic V(Xdcim.Xcim5.W110)=0.0v
.ic V(Xdcim.Xcim5.W111)=0.0v
.ic V(Xdcim.Xcim5.W112)=1.8v
.ic V(Xdcim.Xcim5.W113)=0.0v
.ic V(Xdcim.Xcim5.W120)=0.0v
.ic V(Xdcim.Xcim5.W121)=0.0v
.ic V(Xdcim.Xcim5.W122)=1.8v
.ic V(Xdcim.Xcim5.W123)=0.0v
.ic V(Xdcim.Xcim5.W130)=0.0v
.ic V(Xdcim.Xcim5.W131)=0.0v
.ic V(Xdcim.Xcim5.W132)=1.8v
.ic V(Xdcim.Xcim5.W133)=0.0v
.ic V(Xdcim.Xcim5.W140)=0.0v
.ic V(Xdcim.Xcim5.W141)=0.0v
.ic V(Xdcim.Xcim5.W142)=1.8v
.ic V(Xdcim.Xcim5.W143)=0.0v
.ic V(Xdcim.Xcim5.W150)=0.0v
.ic V(Xdcim.Xcim5.W151)=0.0v
.ic V(Xdcim.Xcim5.W152)=1.8v
.ic V(Xdcim.Xcim5.W153)=0.0v
.ic V(Xdcim.Xcim5.W160)=0.0v
.ic V(Xdcim.Xcim5.W161)=0.0v
.ic V(Xdcim.Xcim5.W162)=1.8v
.ic V(Xdcim.Xcim5.W163)=0.0v
.ic V(Xdcim.Xcim5.W170)=0.0v
.ic V(Xdcim.Xcim5.W171)=0.0v
.ic V(Xdcim.Xcim5.W172)=1.8v
.ic V(Xdcim.Xcim5.W173)=0.0v
.ic V(Xdcim.Xcim5.W180)=0.0v
.ic V(Xdcim.Xcim5.W181)=0.0v
.ic V(Xdcim.Xcim5.W182)=1.8v
.ic V(Xdcim.Xcim5.W183)=0.0v
.ic V(Xdcim.Xcim5.W190)=0.0v
.ic V(Xdcim.Xcim5.W191)=0.0v
.ic V(Xdcim.Xcim5.W192)=1.8v
.ic V(Xdcim.Xcim5.W193)=0.0v
.ic V(Xdcim.Xcim5.W200)=0.0v
.ic V(Xdcim.Xcim5.W201)=0.0v
.ic V(Xdcim.Xcim5.W202)=1.8v
.ic V(Xdcim.Xcim5.W203)=0.0v
.ic V(Xdcim.Xcim5.W210)=0.0v
.ic V(Xdcim.Xcim5.W211)=0.0v
.ic V(Xdcim.Xcim5.W212)=1.8v
.ic V(Xdcim.Xcim5.W213)=0.0v
.ic V(Xdcim.Xcim5.W220)=0.0v
.ic V(Xdcim.Xcim5.W221)=0.0v
.ic V(Xdcim.Xcim5.W222)=1.8v
.ic V(Xdcim.Xcim5.W223)=0.0v
.ic V(Xdcim.Xcim5.W230)=0.0v
.ic V(Xdcim.Xcim5.W231)=0.0v
.ic V(Xdcim.Xcim5.W232)=1.8v
.ic V(Xdcim.Xcim5.W233)=0.0v
.ic V(Xdcim.Xcim5.W240)=0.0v
.ic V(Xdcim.Xcim5.W241)=0.0v
.ic V(Xdcim.Xcim5.W242)=1.8v
.ic V(Xdcim.Xcim5.W243)=0.0v
.ic V(Xdcim.Xcim5.W250)=0.0v
.ic V(Xdcim.Xcim5.W251)=0.0v
.ic V(Xdcim.Xcim5.W252)=1.8v
.ic V(Xdcim.Xcim5.W253)=0.0v
.ic V(Xdcim.Xcim5.W260)=0.0v
.ic V(Xdcim.Xcim5.W261)=0.0v
.ic V(Xdcim.Xcim5.W262)=1.8v
.ic V(Xdcim.Xcim5.W263)=0.0v
.ic V(Xdcim.Xcim5.W270)=0.0v
.ic V(Xdcim.Xcim5.W271)=0.0v
.ic V(Xdcim.Xcim5.W272)=1.8v
.ic V(Xdcim.Xcim5.W273)=0.0v
.ic V(Xdcim.Xcim5.W280)=0.0v
.ic V(Xdcim.Xcim5.W281)=0.0v
.ic V(Xdcim.Xcim5.W282)=1.8v
.ic V(Xdcim.Xcim5.W283)=0.0v
.ic V(Xdcim.Xcim5.W290)=0.0v
.ic V(Xdcim.Xcim5.W291)=0.0v
.ic V(Xdcim.Xcim5.W292)=1.8v
.ic V(Xdcim.Xcim5.W293)=0.0v
.ic V(Xdcim.Xcim5.W300)=0.0v
.ic V(Xdcim.Xcim5.W301)=0.0v
.ic V(Xdcim.Xcim5.W302)=1.8v
.ic V(Xdcim.Xcim5.W303)=0.0v
.ic V(Xdcim.Xcim5.W310)=0.0v
.ic V(Xdcim.Xcim5.W311)=0.0v
.ic V(Xdcim.Xcim5.W312)=1.8v
.ic V(Xdcim.Xcim5.W313)=0.0v
.ic V(Xdcim.Xcim5.W320)=0.0v
.ic V(Xdcim.Xcim5.W321)=0.0v
.ic V(Xdcim.Xcim5.W322)=1.8v
.ic V(Xdcim.Xcim5.W323)=0.0v
.ic V(Xdcim.Xcim6.W10)=1.8v
.ic V(Xdcim.Xcim6.W11)=0.0v
.ic V(Xdcim.Xcim6.W12)=1.8v
.ic V(Xdcim.Xcim6.W13)=0.0v
.ic V(Xdcim.Xcim6.W20)=1.8v
.ic V(Xdcim.Xcim6.W21)=0.0v
.ic V(Xdcim.Xcim6.W22)=1.8v
.ic V(Xdcim.Xcim6.W23)=0.0v
.ic V(Xdcim.Xcim6.W30)=1.8v
.ic V(Xdcim.Xcim6.W31)=0.0v
.ic V(Xdcim.Xcim6.W32)=1.8v
.ic V(Xdcim.Xcim6.W33)=0.0v
.ic V(Xdcim.Xcim6.W40)=1.8v
.ic V(Xdcim.Xcim6.W41)=0.0v
.ic V(Xdcim.Xcim6.W42)=1.8v
.ic V(Xdcim.Xcim6.W43)=0.0v
.ic V(Xdcim.Xcim6.W50)=1.8v
.ic V(Xdcim.Xcim6.W51)=0.0v
.ic V(Xdcim.Xcim6.W52)=1.8v
.ic V(Xdcim.Xcim6.W53)=0.0v
.ic V(Xdcim.Xcim6.W60)=1.8v
.ic V(Xdcim.Xcim6.W61)=0.0v
.ic V(Xdcim.Xcim6.W62)=1.8v
.ic V(Xdcim.Xcim6.W63)=0.0v
.ic V(Xdcim.Xcim6.W70)=1.8v
.ic V(Xdcim.Xcim6.W71)=0.0v
.ic V(Xdcim.Xcim6.W72)=1.8v
.ic V(Xdcim.Xcim6.W73)=0.0v
.ic V(Xdcim.Xcim6.W80)=1.8v
.ic V(Xdcim.Xcim6.W81)=0.0v
.ic V(Xdcim.Xcim6.W82)=1.8v
.ic V(Xdcim.Xcim6.W83)=0.0v
.ic V(Xdcim.Xcim6.W90)=1.8v
.ic V(Xdcim.Xcim6.W91)=0.0v
.ic V(Xdcim.Xcim6.W92)=1.8v
.ic V(Xdcim.Xcim6.W93)=0.0v
.ic V(Xdcim.Xcim6.W100)=1.8v
.ic V(Xdcim.Xcim6.W101)=0.0v
.ic V(Xdcim.Xcim6.W102)=1.8v
.ic V(Xdcim.Xcim6.W103)=0.0v
.ic V(Xdcim.Xcim6.W110)=1.8v
.ic V(Xdcim.Xcim6.W111)=0.0v
.ic V(Xdcim.Xcim6.W112)=1.8v
.ic V(Xdcim.Xcim6.W113)=0.0v
.ic V(Xdcim.Xcim6.W120)=1.8v
.ic V(Xdcim.Xcim6.W121)=0.0v
.ic V(Xdcim.Xcim6.W122)=1.8v
.ic V(Xdcim.Xcim6.W123)=0.0v
.ic V(Xdcim.Xcim6.W130)=1.8v
.ic V(Xdcim.Xcim6.W131)=0.0v
.ic V(Xdcim.Xcim6.W132)=1.8v
.ic V(Xdcim.Xcim6.W133)=0.0v
.ic V(Xdcim.Xcim6.W140)=1.8v
.ic V(Xdcim.Xcim6.W141)=0.0v
.ic V(Xdcim.Xcim6.W142)=1.8v
.ic V(Xdcim.Xcim6.W143)=0.0v
.ic V(Xdcim.Xcim6.W150)=1.8v
.ic V(Xdcim.Xcim6.W151)=0.0v
.ic V(Xdcim.Xcim6.W152)=1.8v
.ic V(Xdcim.Xcim6.W153)=0.0v
.ic V(Xdcim.Xcim6.W160)=1.8v
.ic V(Xdcim.Xcim6.W161)=0.0v
.ic V(Xdcim.Xcim6.W162)=1.8v
.ic V(Xdcim.Xcim6.W163)=0.0v
.ic V(Xdcim.Xcim6.W170)=1.8v
.ic V(Xdcim.Xcim6.W171)=0.0v
.ic V(Xdcim.Xcim6.W172)=1.8v
.ic V(Xdcim.Xcim6.W173)=0.0v
.ic V(Xdcim.Xcim6.W180)=1.8v
.ic V(Xdcim.Xcim6.W181)=0.0v
.ic V(Xdcim.Xcim6.W182)=1.8v
.ic V(Xdcim.Xcim6.W183)=0.0v
.ic V(Xdcim.Xcim6.W190)=1.8v
.ic V(Xdcim.Xcim6.W191)=0.0v
.ic V(Xdcim.Xcim6.W192)=1.8v
.ic V(Xdcim.Xcim6.W193)=0.0v
.ic V(Xdcim.Xcim6.W200)=1.8v
.ic V(Xdcim.Xcim6.W201)=0.0v
.ic V(Xdcim.Xcim6.W202)=1.8v
.ic V(Xdcim.Xcim6.W203)=0.0v
.ic V(Xdcim.Xcim6.W210)=1.8v
.ic V(Xdcim.Xcim6.W211)=0.0v
.ic V(Xdcim.Xcim6.W212)=1.8v
.ic V(Xdcim.Xcim6.W213)=0.0v
.ic V(Xdcim.Xcim6.W220)=1.8v
.ic V(Xdcim.Xcim6.W221)=0.0v
.ic V(Xdcim.Xcim6.W222)=1.8v
.ic V(Xdcim.Xcim6.W223)=0.0v
.ic V(Xdcim.Xcim6.W230)=1.8v
.ic V(Xdcim.Xcim6.W231)=0.0v
.ic V(Xdcim.Xcim6.W232)=1.8v
.ic V(Xdcim.Xcim6.W233)=0.0v
.ic V(Xdcim.Xcim6.W240)=1.8v
.ic V(Xdcim.Xcim6.W241)=0.0v
.ic V(Xdcim.Xcim6.W242)=1.8v
.ic V(Xdcim.Xcim6.W243)=0.0v
.ic V(Xdcim.Xcim6.W250)=1.8v
.ic V(Xdcim.Xcim6.W251)=0.0v
.ic V(Xdcim.Xcim6.W252)=1.8v
.ic V(Xdcim.Xcim6.W253)=0.0v
.ic V(Xdcim.Xcim6.W260)=1.8v
.ic V(Xdcim.Xcim6.W261)=0.0v
.ic V(Xdcim.Xcim6.W262)=1.8v
.ic V(Xdcim.Xcim6.W263)=0.0v
.ic V(Xdcim.Xcim6.W270)=1.8v
.ic V(Xdcim.Xcim6.W271)=0.0v
.ic V(Xdcim.Xcim6.W272)=1.8v
.ic V(Xdcim.Xcim6.W273)=0.0v
.ic V(Xdcim.Xcim6.W280)=1.8v
.ic V(Xdcim.Xcim6.W281)=0.0v
.ic V(Xdcim.Xcim6.W282)=1.8v
.ic V(Xdcim.Xcim6.W283)=0.0v
.ic V(Xdcim.Xcim6.W290)=1.8v
.ic V(Xdcim.Xcim6.W291)=0.0v
.ic V(Xdcim.Xcim6.W292)=1.8v
.ic V(Xdcim.Xcim6.W293)=0.0v
.ic V(Xdcim.Xcim6.W300)=1.8v
.ic V(Xdcim.Xcim6.W301)=0.0v
.ic V(Xdcim.Xcim6.W302)=1.8v
.ic V(Xdcim.Xcim6.W303)=0.0v
.ic V(Xdcim.Xcim6.W310)=1.8v
.ic V(Xdcim.Xcim6.W311)=0.0v
.ic V(Xdcim.Xcim6.W312)=1.8v
.ic V(Xdcim.Xcim6.W313)=0.0v
.ic V(Xdcim.Xcim6.W320)=1.8v
.ic V(Xdcim.Xcim6.W321)=0.0v
.ic V(Xdcim.Xcim6.W322)=1.8v
.ic V(Xdcim.Xcim6.W323)=0.0v
.ic V(Xdcim.Xcim7.W10)=0.0v
.ic V(Xdcim.Xcim7.W11)=1.8v
.ic V(Xdcim.Xcim7.W12)=1.8v
.ic V(Xdcim.Xcim7.W13)=0.0v
.ic V(Xdcim.Xcim7.W20)=0.0v
.ic V(Xdcim.Xcim7.W21)=1.8v
.ic V(Xdcim.Xcim7.W22)=1.8v
.ic V(Xdcim.Xcim7.W23)=0.0v
.ic V(Xdcim.Xcim7.W30)=0.0v
.ic V(Xdcim.Xcim7.W31)=1.8v
.ic V(Xdcim.Xcim7.W32)=1.8v
.ic V(Xdcim.Xcim7.W33)=0.0v
.ic V(Xdcim.Xcim7.W40)=0.0v
.ic V(Xdcim.Xcim7.W41)=1.8v
.ic V(Xdcim.Xcim7.W42)=1.8v
.ic V(Xdcim.Xcim7.W43)=0.0v
.ic V(Xdcim.Xcim7.W50)=0.0v
.ic V(Xdcim.Xcim7.W51)=1.8v
.ic V(Xdcim.Xcim7.W52)=1.8v
.ic V(Xdcim.Xcim7.W53)=0.0v
.ic V(Xdcim.Xcim7.W60)=0.0v
.ic V(Xdcim.Xcim7.W61)=1.8v
.ic V(Xdcim.Xcim7.W62)=1.8v
.ic V(Xdcim.Xcim7.W63)=0.0v
.ic V(Xdcim.Xcim7.W70)=0.0v
.ic V(Xdcim.Xcim7.W71)=1.8v
.ic V(Xdcim.Xcim7.W72)=1.8v
.ic V(Xdcim.Xcim7.W73)=0.0v
.ic V(Xdcim.Xcim7.W80)=0.0v
.ic V(Xdcim.Xcim7.W81)=1.8v
.ic V(Xdcim.Xcim7.W82)=1.8v
.ic V(Xdcim.Xcim7.W83)=0.0v
.ic V(Xdcim.Xcim7.W90)=0.0v
.ic V(Xdcim.Xcim7.W91)=1.8v
.ic V(Xdcim.Xcim7.W92)=1.8v
.ic V(Xdcim.Xcim7.W93)=0.0v
.ic V(Xdcim.Xcim7.W100)=0.0v
.ic V(Xdcim.Xcim7.W101)=1.8v
.ic V(Xdcim.Xcim7.W102)=1.8v
.ic V(Xdcim.Xcim7.W103)=0.0v
.ic V(Xdcim.Xcim7.W110)=0.0v
.ic V(Xdcim.Xcim7.W111)=1.8v
.ic V(Xdcim.Xcim7.W112)=1.8v
.ic V(Xdcim.Xcim7.W113)=0.0v
.ic V(Xdcim.Xcim7.W120)=0.0v
.ic V(Xdcim.Xcim7.W121)=1.8v
.ic V(Xdcim.Xcim7.W122)=1.8v
.ic V(Xdcim.Xcim7.W123)=0.0v
.ic V(Xdcim.Xcim7.W130)=0.0v
.ic V(Xdcim.Xcim7.W131)=1.8v
.ic V(Xdcim.Xcim7.W132)=1.8v
.ic V(Xdcim.Xcim7.W133)=0.0v
.ic V(Xdcim.Xcim7.W140)=0.0v
.ic V(Xdcim.Xcim7.W141)=1.8v
.ic V(Xdcim.Xcim7.W142)=1.8v
.ic V(Xdcim.Xcim7.W143)=0.0v
.ic V(Xdcim.Xcim7.W150)=0.0v
.ic V(Xdcim.Xcim7.W151)=1.8v
.ic V(Xdcim.Xcim7.W152)=1.8v
.ic V(Xdcim.Xcim7.W153)=0.0v
.ic V(Xdcim.Xcim7.W160)=0.0v
.ic V(Xdcim.Xcim7.W161)=1.8v
.ic V(Xdcim.Xcim7.W162)=1.8v
.ic V(Xdcim.Xcim7.W163)=0.0v
.ic V(Xdcim.Xcim7.W170)=0.0v
.ic V(Xdcim.Xcim7.W171)=1.8v
.ic V(Xdcim.Xcim7.W172)=1.8v
.ic V(Xdcim.Xcim7.W173)=0.0v
.ic V(Xdcim.Xcim7.W180)=0.0v
.ic V(Xdcim.Xcim7.W181)=1.8v
.ic V(Xdcim.Xcim7.W182)=1.8v
.ic V(Xdcim.Xcim7.W183)=0.0v
.ic V(Xdcim.Xcim7.W190)=0.0v
.ic V(Xdcim.Xcim7.W191)=1.8v
.ic V(Xdcim.Xcim7.W192)=1.8v
.ic V(Xdcim.Xcim7.W193)=0.0v
.ic V(Xdcim.Xcim7.W200)=0.0v
.ic V(Xdcim.Xcim7.W201)=1.8v
.ic V(Xdcim.Xcim7.W202)=1.8v
.ic V(Xdcim.Xcim7.W203)=0.0v
.ic V(Xdcim.Xcim7.W210)=0.0v
.ic V(Xdcim.Xcim7.W211)=1.8v
.ic V(Xdcim.Xcim7.W212)=1.8v
.ic V(Xdcim.Xcim7.W213)=0.0v
.ic V(Xdcim.Xcim7.W220)=0.0v
.ic V(Xdcim.Xcim7.W221)=1.8v
.ic V(Xdcim.Xcim7.W222)=1.8v
.ic V(Xdcim.Xcim7.W223)=0.0v
.ic V(Xdcim.Xcim7.W230)=0.0v
.ic V(Xdcim.Xcim7.W231)=1.8v
.ic V(Xdcim.Xcim7.W232)=1.8v
.ic V(Xdcim.Xcim7.W233)=0.0v
.ic V(Xdcim.Xcim7.W240)=0.0v
.ic V(Xdcim.Xcim7.W241)=1.8v
.ic V(Xdcim.Xcim7.W242)=1.8v
.ic V(Xdcim.Xcim7.W243)=0.0v
.ic V(Xdcim.Xcim7.W250)=0.0v
.ic V(Xdcim.Xcim7.W251)=1.8v
.ic V(Xdcim.Xcim7.W252)=1.8v
.ic V(Xdcim.Xcim7.W253)=0.0v
.ic V(Xdcim.Xcim7.W260)=0.0v
.ic V(Xdcim.Xcim7.W261)=1.8v
.ic V(Xdcim.Xcim7.W262)=1.8v
.ic V(Xdcim.Xcim7.W263)=0.0v
.ic V(Xdcim.Xcim7.W270)=0.0v
.ic V(Xdcim.Xcim7.W271)=1.8v
.ic V(Xdcim.Xcim7.W272)=1.8v
.ic V(Xdcim.Xcim7.W273)=0.0v
.ic V(Xdcim.Xcim7.W280)=0.0v
.ic V(Xdcim.Xcim7.W281)=1.8v
.ic V(Xdcim.Xcim7.W282)=1.8v
.ic V(Xdcim.Xcim7.W283)=0.0v
.ic V(Xdcim.Xcim7.W290)=0.0v
.ic V(Xdcim.Xcim7.W291)=1.8v
.ic V(Xdcim.Xcim7.W292)=1.8v
.ic V(Xdcim.Xcim7.W293)=0.0v
.ic V(Xdcim.Xcim7.W300)=0.0v
.ic V(Xdcim.Xcim7.W301)=1.8v
.ic V(Xdcim.Xcim7.W302)=1.8v
.ic V(Xdcim.Xcim7.W303)=0.0v
.ic V(Xdcim.Xcim7.W310)=0.0v
.ic V(Xdcim.Xcim7.W311)=1.8v
.ic V(Xdcim.Xcim7.W312)=1.8v
.ic V(Xdcim.Xcim7.W313)=0.0v
.ic V(Xdcim.Xcim7.W320)=0.0v
.ic V(Xdcim.Xcim7.W321)=1.8v
.ic V(Xdcim.Xcim7.W322)=1.8v
.ic V(Xdcim.Xcim7.W323)=0.0v
.ic V(Xdcim.Xcim8.W10)=1.8v
.ic V(Xdcim.Xcim8.W11)=1.8v
.ic V(Xdcim.Xcim8.W12)=1.8v
.ic V(Xdcim.Xcim8.W13)=0.0v
.ic V(Xdcim.Xcim8.W20)=1.8v
.ic V(Xdcim.Xcim8.W21)=1.8v
.ic V(Xdcim.Xcim8.W22)=1.8v
.ic V(Xdcim.Xcim8.W23)=0.0v
.ic V(Xdcim.Xcim8.W30)=1.8v
.ic V(Xdcim.Xcim8.W31)=1.8v
.ic V(Xdcim.Xcim8.W32)=1.8v
.ic V(Xdcim.Xcim8.W33)=0.0v
.ic V(Xdcim.Xcim8.W40)=1.8v
.ic V(Xdcim.Xcim8.W41)=1.8v
.ic V(Xdcim.Xcim8.W42)=1.8v
.ic V(Xdcim.Xcim8.W43)=0.0v
.ic V(Xdcim.Xcim8.W50)=1.8v
.ic V(Xdcim.Xcim8.W51)=1.8v
.ic V(Xdcim.Xcim8.W52)=1.8v
.ic V(Xdcim.Xcim8.W53)=0.0v
.ic V(Xdcim.Xcim8.W60)=1.8v
.ic V(Xdcim.Xcim8.W61)=1.8v
.ic V(Xdcim.Xcim8.W62)=1.8v
.ic V(Xdcim.Xcim8.W63)=0.0v
.ic V(Xdcim.Xcim8.W70)=1.8v
.ic V(Xdcim.Xcim8.W71)=1.8v
.ic V(Xdcim.Xcim8.W72)=1.8v
.ic V(Xdcim.Xcim8.W73)=0.0v
.ic V(Xdcim.Xcim8.W80)=1.8v
.ic V(Xdcim.Xcim8.W81)=1.8v
.ic V(Xdcim.Xcim8.W82)=1.8v
.ic V(Xdcim.Xcim8.W83)=0.0v
.ic V(Xdcim.Xcim8.W90)=1.8v
.ic V(Xdcim.Xcim8.W91)=1.8v
.ic V(Xdcim.Xcim8.W92)=1.8v
.ic V(Xdcim.Xcim8.W93)=0.0v
.ic V(Xdcim.Xcim8.W100)=1.8v
.ic V(Xdcim.Xcim8.W101)=1.8v
.ic V(Xdcim.Xcim8.W102)=1.8v
.ic V(Xdcim.Xcim8.W103)=0.0v
.ic V(Xdcim.Xcim8.W110)=1.8v
.ic V(Xdcim.Xcim8.W111)=1.8v
.ic V(Xdcim.Xcim8.W112)=1.8v
.ic V(Xdcim.Xcim8.W113)=0.0v
.ic V(Xdcim.Xcim8.W120)=1.8v
.ic V(Xdcim.Xcim8.W121)=1.8v
.ic V(Xdcim.Xcim8.W122)=1.8v
.ic V(Xdcim.Xcim8.W123)=0.0v
.ic V(Xdcim.Xcim8.W130)=1.8v
.ic V(Xdcim.Xcim8.W131)=1.8v
.ic V(Xdcim.Xcim8.W132)=1.8v
.ic V(Xdcim.Xcim8.W133)=0.0v
.ic V(Xdcim.Xcim8.W140)=1.8v
.ic V(Xdcim.Xcim8.W141)=1.8v
.ic V(Xdcim.Xcim8.W142)=1.8v
.ic V(Xdcim.Xcim8.W143)=0.0v
.ic V(Xdcim.Xcim8.W150)=1.8v
.ic V(Xdcim.Xcim8.W151)=1.8v
.ic V(Xdcim.Xcim8.W152)=1.8v
.ic V(Xdcim.Xcim8.W153)=0.0v
.ic V(Xdcim.Xcim8.W160)=1.8v
.ic V(Xdcim.Xcim8.W161)=1.8v
.ic V(Xdcim.Xcim8.W162)=1.8v
.ic V(Xdcim.Xcim8.W163)=0.0v
.ic V(Xdcim.Xcim8.W170)=1.8v
.ic V(Xdcim.Xcim8.W171)=1.8v
.ic V(Xdcim.Xcim8.W172)=1.8v
.ic V(Xdcim.Xcim8.W173)=0.0v
.ic V(Xdcim.Xcim8.W180)=1.8v
.ic V(Xdcim.Xcim8.W181)=1.8v
.ic V(Xdcim.Xcim8.W182)=1.8v
.ic V(Xdcim.Xcim8.W183)=0.0v
.ic V(Xdcim.Xcim8.W190)=1.8v
.ic V(Xdcim.Xcim8.W191)=1.8v
.ic V(Xdcim.Xcim8.W192)=1.8v
.ic V(Xdcim.Xcim8.W193)=0.0v
.ic V(Xdcim.Xcim8.W200)=1.8v
.ic V(Xdcim.Xcim8.W201)=1.8v
.ic V(Xdcim.Xcim8.W202)=1.8v
.ic V(Xdcim.Xcim8.W203)=0.0v
.ic V(Xdcim.Xcim8.W210)=1.8v
.ic V(Xdcim.Xcim8.W211)=1.8v
.ic V(Xdcim.Xcim8.W212)=1.8v
.ic V(Xdcim.Xcim8.W213)=0.0v
.ic V(Xdcim.Xcim8.W220)=1.8v
.ic V(Xdcim.Xcim8.W221)=1.8v
.ic V(Xdcim.Xcim8.W222)=1.8v
.ic V(Xdcim.Xcim8.W223)=0.0v
.ic V(Xdcim.Xcim8.W230)=1.8v
.ic V(Xdcim.Xcim8.W231)=1.8v
.ic V(Xdcim.Xcim8.W232)=1.8v
.ic V(Xdcim.Xcim8.W233)=0.0v
.ic V(Xdcim.Xcim8.W240)=1.8v
.ic V(Xdcim.Xcim8.W241)=1.8v
.ic V(Xdcim.Xcim8.W242)=1.8v
.ic V(Xdcim.Xcim8.W243)=0.0v
.ic V(Xdcim.Xcim8.W250)=1.8v
.ic V(Xdcim.Xcim8.W251)=1.8v
.ic V(Xdcim.Xcim8.W252)=1.8v
.ic V(Xdcim.Xcim8.W253)=0.0v
.ic V(Xdcim.Xcim8.W260)=1.8v
.ic V(Xdcim.Xcim8.W261)=1.8v
.ic V(Xdcim.Xcim8.W262)=1.8v
.ic V(Xdcim.Xcim8.W263)=0.0v
.ic V(Xdcim.Xcim8.W270)=1.8v
.ic V(Xdcim.Xcim8.W271)=1.8v
.ic V(Xdcim.Xcim8.W272)=1.8v
.ic V(Xdcim.Xcim8.W273)=0.0v
.ic V(Xdcim.Xcim8.W280)=1.8v
.ic V(Xdcim.Xcim8.W281)=1.8v
.ic V(Xdcim.Xcim8.W282)=1.8v
.ic V(Xdcim.Xcim8.W283)=0.0v
.ic V(Xdcim.Xcim8.W290)=1.8v
.ic V(Xdcim.Xcim8.W291)=1.8v
.ic V(Xdcim.Xcim8.W292)=1.8v
.ic V(Xdcim.Xcim8.W293)=0.0v
.ic V(Xdcim.Xcim8.W300)=1.8v
.ic V(Xdcim.Xcim8.W301)=1.8v
.ic V(Xdcim.Xcim8.W302)=1.8v
.ic V(Xdcim.Xcim8.W303)=0.0v
.ic V(Xdcim.Xcim8.W310)=1.8v
.ic V(Xdcim.Xcim8.W311)=1.8v
.ic V(Xdcim.Xcim8.W312)=1.8v
.ic V(Xdcim.Xcim8.W313)=0.0v
.ic V(Xdcim.Xcim8.W320)=1.8v
.ic V(Xdcim.Xcim8.W321)=1.8v
.ic V(Xdcim.Xcim8.W322)=1.8v
.ic V(Xdcim.Xcim8.W323)=0.0v
.ic V(Xdcim.Xcim9.W10)=0.0v
.ic V(Xdcim.Xcim9.W11)=0.0v
.ic V(Xdcim.Xcim9.W12)=0.0v
.ic V(Xdcim.Xcim9.W13)=1.8v
.ic V(Xdcim.Xcim9.W20)=0.0v
.ic V(Xdcim.Xcim9.W21)=0.0v
.ic V(Xdcim.Xcim9.W22)=0.0v
.ic V(Xdcim.Xcim9.W23)=1.8v
.ic V(Xdcim.Xcim9.W30)=0.0v
.ic V(Xdcim.Xcim9.W31)=0.0v
.ic V(Xdcim.Xcim9.W32)=0.0v
.ic V(Xdcim.Xcim9.W33)=1.8v
.ic V(Xdcim.Xcim9.W40)=0.0v
.ic V(Xdcim.Xcim9.W41)=0.0v
.ic V(Xdcim.Xcim9.W42)=0.0v
.ic V(Xdcim.Xcim9.W43)=1.8v
.ic V(Xdcim.Xcim9.W50)=0.0v
.ic V(Xdcim.Xcim9.W51)=0.0v
.ic V(Xdcim.Xcim9.W52)=0.0v
.ic V(Xdcim.Xcim9.W53)=1.8v
.ic V(Xdcim.Xcim9.W60)=0.0v
.ic V(Xdcim.Xcim9.W61)=0.0v
.ic V(Xdcim.Xcim9.W62)=0.0v
.ic V(Xdcim.Xcim9.W63)=1.8v
.ic V(Xdcim.Xcim9.W70)=0.0v
.ic V(Xdcim.Xcim9.W71)=0.0v
.ic V(Xdcim.Xcim9.W72)=0.0v
.ic V(Xdcim.Xcim9.W73)=1.8v
.ic V(Xdcim.Xcim9.W80)=0.0v
.ic V(Xdcim.Xcim9.W81)=0.0v
.ic V(Xdcim.Xcim9.W82)=0.0v
.ic V(Xdcim.Xcim9.W83)=1.8v
.ic V(Xdcim.Xcim9.W90)=0.0v
.ic V(Xdcim.Xcim9.W91)=0.0v
.ic V(Xdcim.Xcim9.W92)=0.0v
.ic V(Xdcim.Xcim9.W93)=1.8v
.ic V(Xdcim.Xcim9.W100)=0.0v
.ic V(Xdcim.Xcim9.W101)=0.0v
.ic V(Xdcim.Xcim9.W102)=0.0v
.ic V(Xdcim.Xcim9.W103)=1.8v
.ic V(Xdcim.Xcim9.W110)=0.0v
.ic V(Xdcim.Xcim9.W111)=0.0v
.ic V(Xdcim.Xcim9.W112)=0.0v
.ic V(Xdcim.Xcim9.W113)=1.8v
.ic V(Xdcim.Xcim9.W120)=0.0v
.ic V(Xdcim.Xcim9.W121)=0.0v
.ic V(Xdcim.Xcim9.W122)=0.0v
.ic V(Xdcim.Xcim9.W123)=1.8v
.ic V(Xdcim.Xcim9.W130)=0.0v
.ic V(Xdcim.Xcim9.W131)=0.0v
.ic V(Xdcim.Xcim9.W132)=0.0v
.ic V(Xdcim.Xcim9.W133)=1.8v
.ic V(Xdcim.Xcim9.W140)=0.0v
.ic V(Xdcim.Xcim9.W141)=0.0v
.ic V(Xdcim.Xcim9.W142)=0.0v
.ic V(Xdcim.Xcim9.W143)=1.8v
.ic V(Xdcim.Xcim9.W150)=0.0v
.ic V(Xdcim.Xcim9.W151)=0.0v
.ic V(Xdcim.Xcim9.W152)=0.0v
.ic V(Xdcim.Xcim9.W153)=1.8v
.ic V(Xdcim.Xcim9.W160)=0.0v
.ic V(Xdcim.Xcim9.W161)=0.0v
.ic V(Xdcim.Xcim9.W162)=0.0v
.ic V(Xdcim.Xcim9.W163)=1.8v
.ic V(Xdcim.Xcim9.W170)=0.0v
.ic V(Xdcim.Xcim9.W171)=0.0v
.ic V(Xdcim.Xcim9.W172)=0.0v
.ic V(Xdcim.Xcim9.W173)=1.8v
.ic V(Xdcim.Xcim9.W180)=0.0v
.ic V(Xdcim.Xcim9.W181)=0.0v
.ic V(Xdcim.Xcim9.W182)=0.0v
.ic V(Xdcim.Xcim9.W183)=1.8v
.ic V(Xdcim.Xcim9.W190)=0.0v
.ic V(Xdcim.Xcim9.W191)=0.0v
.ic V(Xdcim.Xcim9.W192)=0.0v
.ic V(Xdcim.Xcim9.W193)=1.8v
.ic V(Xdcim.Xcim9.W200)=0.0v
.ic V(Xdcim.Xcim9.W201)=0.0v
.ic V(Xdcim.Xcim9.W202)=0.0v
.ic V(Xdcim.Xcim9.W203)=1.8v
.ic V(Xdcim.Xcim9.W210)=0.0v
.ic V(Xdcim.Xcim9.W211)=0.0v
.ic V(Xdcim.Xcim9.W212)=0.0v
.ic V(Xdcim.Xcim9.W213)=1.8v
.ic V(Xdcim.Xcim9.W220)=0.0v
.ic V(Xdcim.Xcim9.W221)=0.0v
.ic V(Xdcim.Xcim9.W222)=0.0v
.ic V(Xdcim.Xcim9.W223)=1.8v
.ic V(Xdcim.Xcim9.W230)=0.0v
.ic V(Xdcim.Xcim9.W231)=0.0v
.ic V(Xdcim.Xcim9.W232)=0.0v
.ic V(Xdcim.Xcim9.W233)=1.8v
.ic V(Xdcim.Xcim9.W240)=0.0v
.ic V(Xdcim.Xcim9.W241)=0.0v
.ic V(Xdcim.Xcim9.W242)=0.0v
.ic V(Xdcim.Xcim9.W243)=1.8v
.ic V(Xdcim.Xcim9.W250)=0.0v
.ic V(Xdcim.Xcim9.W251)=0.0v
.ic V(Xdcim.Xcim9.W252)=0.0v
.ic V(Xdcim.Xcim9.W253)=1.8v
.ic V(Xdcim.Xcim9.W260)=0.0v
.ic V(Xdcim.Xcim9.W261)=0.0v
.ic V(Xdcim.Xcim9.W262)=0.0v
.ic V(Xdcim.Xcim9.W263)=1.8v
.ic V(Xdcim.Xcim9.W270)=0.0v
.ic V(Xdcim.Xcim9.W271)=0.0v
.ic V(Xdcim.Xcim9.W272)=0.0v
.ic V(Xdcim.Xcim9.W273)=1.8v
.ic V(Xdcim.Xcim9.W280)=0.0v
.ic V(Xdcim.Xcim9.W281)=0.0v
.ic V(Xdcim.Xcim9.W282)=0.0v
.ic V(Xdcim.Xcim9.W283)=1.8v
.ic V(Xdcim.Xcim9.W290)=0.0v
.ic V(Xdcim.Xcim9.W291)=0.0v
.ic V(Xdcim.Xcim9.W292)=0.0v
.ic V(Xdcim.Xcim9.W293)=1.8v
.ic V(Xdcim.Xcim9.W300)=0.0v
.ic V(Xdcim.Xcim9.W301)=0.0v
.ic V(Xdcim.Xcim9.W302)=0.0v
.ic V(Xdcim.Xcim9.W303)=1.8v
.ic V(Xdcim.Xcim9.W310)=0.0v
.ic V(Xdcim.Xcim9.W311)=0.0v
.ic V(Xdcim.Xcim9.W312)=0.0v
.ic V(Xdcim.Xcim9.W313)=1.8v
.ic V(Xdcim.Xcim9.W320)=0.0v
.ic V(Xdcim.Xcim9.W321)=0.0v
.ic V(Xdcim.Xcim9.W322)=0.0v
.ic V(Xdcim.Xcim9.W323)=1.8v
.ic V(Xdcim.Xcim10.W10)=1.8v
.ic V(Xdcim.Xcim10.W11)=0.0v
.ic V(Xdcim.Xcim10.W12)=0.0v
.ic V(Xdcim.Xcim10.W13)=1.8v
.ic V(Xdcim.Xcim10.W20)=1.8v
.ic V(Xdcim.Xcim10.W21)=0.0v
.ic V(Xdcim.Xcim10.W22)=0.0v
.ic V(Xdcim.Xcim10.W23)=1.8v
.ic V(Xdcim.Xcim10.W30)=1.8v
.ic V(Xdcim.Xcim10.W31)=0.0v
.ic V(Xdcim.Xcim10.W32)=0.0v
.ic V(Xdcim.Xcim10.W33)=1.8v
.ic V(Xdcim.Xcim10.W40)=1.8v
.ic V(Xdcim.Xcim10.W41)=0.0v
.ic V(Xdcim.Xcim10.W42)=0.0v
.ic V(Xdcim.Xcim10.W43)=1.8v
.ic V(Xdcim.Xcim10.W50)=1.8v
.ic V(Xdcim.Xcim10.W51)=0.0v
.ic V(Xdcim.Xcim10.W52)=0.0v
.ic V(Xdcim.Xcim10.W53)=1.8v
.ic V(Xdcim.Xcim10.W60)=1.8v
.ic V(Xdcim.Xcim10.W61)=0.0v
.ic V(Xdcim.Xcim10.W62)=0.0v
.ic V(Xdcim.Xcim10.W63)=1.8v
.ic V(Xdcim.Xcim10.W70)=1.8v
.ic V(Xdcim.Xcim10.W71)=0.0v
.ic V(Xdcim.Xcim10.W72)=0.0v
.ic V(Xdcim.Xcim10.W73)=1.8v
.ic V(Xdcim.Xcim10.W80)=1.8v
.ic V(Xdcim.Xcim10.W81)=0.0v
.ic V(Xdcim.Xcim10.W82)=0.0v
.ic V(Xdcim.Xcim10.W83)=1.8v
.ic V(Xdcim.Xcim10.W90)=1.8v
.ic V(Xdcim.Xcim10.W91)=0.0v
.ic V(Xdcim.Xcim10.W92)=0.0v
.ic V(Xdcim.Xcim10.W93)=1.8v
.ic V(Xdcim.Xcim10.W100)=1.8v
.ic V(Xdcim.Xcim10.W101)=0.0v
.ic V(Xdcim.Xcim10.W102)=0.0v
.ic V(Xdcim.Xcim10.W103)=1.8v
.ic V(Xdcim.Xcim10.W110)=1.8v
.ic V(Xdcim.Xcim10.W111)=0.0v
.ic V(Xdcim.Xcim10.W112)=0.0v
.ic V(Xdcim.Xcim10.W113)=1.8v
.ic V(Xdcim.Xcim10.W120)=1.8v
.ic V(Xdcim.Xcim10.W121)=0.0v
.ic V(Xdcim.Xcim10.W122)=0.0v
.ic V(Xdcim.Xcim10.W123)=1.8v
.ic V(Xdcim.Xcim10.W130)=1.8v
.ic V(Xdcim.Xcim10.W131)=0.0v
.ic V(Xdcim.Xcim10.W132)=0.0v
.ic V(Xdcim.Xcim10.W133)=1.8v
.ic V(Xdcim.Xcim10.W140)=1.8v
.ic V(Xdcim.Xcim10.W141)=0.0v
.ic V(Xdcim.Xcim10.W142)=0.0v
.ic V(Xdcim.Xcim10.W143)=1.8v
.ic V(Xdcim.Xcim10.W150)=1.8v
.ic V(Xdcim.Xcim10.W151)=0.0v
.ic V(Xdcim.Xcim10.W152)=0.0v
.ic V(Xdcim.Xcim10.W153)=1.8v
.ic V(Xdcim.Xcim10.W160)=1.8v
.ic V(Xdcim.Xcim10.W161)=0.0v
.ic V(Xdcim.Xcim10.W162)=0.0v
.ic V(Xdcim.Xcim10.W163)=1.8v
.ic V(Xdcim.Xcim10.W170)=1.8v
.ic V(Xdcim.Xcim10.W171)=0.0v
.ic V(Xdcim.Xcim10.W172)=0.0v
.ic V(Xdcim.Xcim10.W173)=1.8v
.ic V(Xdcim.Xcim10.W180)=1.8v
.ic V(Xdcim.Xcim10.W181)=0.0v
.ic V(Xdcim.Xcim10.W182)=0.0v
.ic V(Xdcim.Xcim10.W183)=1.8v
.ic V(Xdcim.Xcim10.W190)=1.8v
.ic V(Xdcim.Xcim10.W191)=0.0v
.ic V(Xdcim.Xcim10.W192)=0.0v
.ic V(Xdcim.Xcim10.W193)=1.8v
.ic V(Xdcim.Xcim10.W200)=1.8v
.ic V(Xdcim.Xcim10.W201)=0.0v
.ic V(Xdcim.Xcim10.W202)=0.0v
.ic V(Xdcim.Xcim10.W203)=1.8v
.ic V(Xdcim.Xcim10.W210)=1.8v
.ic V(Xdcim.Xcim10.W211)=0.0v
.ic V(Xdcim.Xcim10.W212)=0.0v
.ic V(Xdcim.Xcim10.W213)=1.8v
.ic V(Xdcim.Xcim10.W220)=1.8v
.ic V(Xdcim.Xcim10.W221)=0.0v
.ic V(Xdcim.Xcim10.W222)=0.0v
.ic V(Xdcim.Xcim10.W223)=1.8v
.ic V(Xdcim.Xcim10.W230)=1.8v
.ic V(Xdcim.Xcim10.W231)=0.0v
.ic V(Xdcim.Xcim10.W232)=0.0v
.ic V(Xdcim.Xcim10.W233)=1.8v
.ic V(Xdcim.Xcim10.W240)=1.8v
.ic V(Xdcim.Xcim10.W241)=0.0v
.ic V(Xdcim.Xcim10.W242)=0.0v
.ic V(Xdcim.Xcim10.W243)=1.8v
.ic V(Xdcim.Xcim10.W250)=1.8v
.ic V(Xdcim.Xcim10.W251)=0.0v
.ic V(Xdcim.Xcim10.W252)=0.0v
.ic V(Xdcim.Xcim10.W253)=1.8v
.ic V(Xdcim.Xcim10.W260)=1.8v
.ic V(Xdcim.Xcim10.W261)=0.0v
.ic V(Xdcim.Xcim10.W262)=0.0v
.ic V(Xdcim.Xcim10.W263)=1.8v
.ic V(Xdcim.Xcim10.W270)=1.8v
.ic V(Xdcim.Xcim10.W271)=0.0v
.ic V(Xdcim.Xcim10.W272)=0.0v
.ic V(Xdcim.Xcim10.W273)=1.8v
.ic V(Xdcim.Xcim10.W280)=1.8v
.ic V(Xdcim.Xcim10.W281)=0.0v
.ic V(Xdcim.Xcim10.W282)=0.0v
.ic V(Xdcim.Xcim10.W283)=1.8v
.ic V(Xdcim.Xcim10.W290)=1.8v
.ic V(Xdcim.Xcim10.W291)=0.0v
.ic V(Xdcim.Xcim10.W292)=0.0v
.ic V(Xdcim.Xcim10.W293)=1.8v
.ic V(Xdcim.Xcim10.W300)=1.8v
.ic V(Xdcim.Xcim10.W301)=0.0v
.ic V(Xdcim.Xcim10.W302)=0.0v
.ic V(Xdcim.Xcim10.W303)=1.8v
.ic V(Xdcim.Xcim10.W310)=1.8v
.ic V(Xdcim.Xcim10.W311)=0.0v
.ic V(Xdcim.Xcim10.W312)=0.0v
.ic V(Xdcim.Xcim10.W313)=1.8v
.ic V(Xdcim.Xcim10.W320)=1.8v
.ic V(Xdcim.Xcim10.W321)=0.0v
.ic V(Xdcim.Xcim10.W322)=0.0v
.ic V(Xdcim.Xcim10.W323)=1.8v
.ic V(Xdcim.Xcim11.W10)=0.0v
.ic V(Xdcim.Xcim11.W11)=1.8v
.ic V(Xdcim.Xcim11.W12)=0.0v
.ic V(Xdcim.Xcim11.W13)=1.8v
.ic V(Xdcim.Xcim11.W20)=0.0v
.ic V(Xdcim.Xcim11.W21)=1.8v
.ic V(Xdcim.Xcim11.W22)=0.0v
.ic V(Xdcim.Xcim11.W23)=1.8v
.ic V(Xdcim.Xcim11.W30)=0.0v
.ic V(Xdcim.Xcim11.W31)=1.8v
.ic V(Xdcim.Xcim11.W32)=0.0v
.ic V(Xdcim.Xcim11.W33)=1.8v
.ic V(Xdcim.Xcim11.W40)=0.0v
.ic V(Xdcim.Xcim11.W41)=1.8v
.ic V(Xdcim.Xcim11.W42)=0.0v
.ic V(Xdcim.Xcim11.W43)=1.8v
.ic V(Xdcim.Xcim11.W50)=0.0v
.ic V(Xdcim.Xcim11.W51)=1.8v
.ic V(Xdcim.Xcim11.W52)=0.0v
.ic V(Xdcim.Xcim11.W53)=1.8v
.ic V(Xdcim.Xcim11.W60)=0.0v
.ic V(Xdcim.Xcim11.W61)=1.8v
.ic V(Xdcim.Xcim11.W62)=0.0v
.ic V(Xdcim.Xcim11.W63)=1.8v
.ic V(Xdcim.Xcim11.W70)=0.0v
.ic V(Xdcim.Xcim11.W71)=1.8v
.ic V(Xdcim.Xcim11.W72)=0.0v
.ic V(Xdcim.Xcim11.W73)=1.8v
.ic V(Xdcim.Xcim11.W80)=0.0v
.ic V(Xdcim.Xcim11.W81)=1.8v
.ic V(Xdcim.Xcim11.W82)=0.0v
.ic V(Xdcim.Xcim11.W83)=1.8v
.ic V(Xdcim.Xcim11.W90)=0.0v
.ic V(Xdcim.Xcim11.W91)=1.8v
.ic V(Xdcim.Xcim11.W92)=0.0v
.ic V(Xdcim.Xcim11.W93)=1.8v
.ic V(Xdcim.Xcim11.W100)=0.0v
.ic V(Xdcim.Xcim11.W101)=1.8v
.ic V(Xdcim.Xcim11.W102)=0.0v
.ic V(Xdcim.Xcim11.W103)=1.8v
.ic V(Xdcim.Xcim11.W110)=0.0v
.ic V(Xdcim.Xcim11.W111)=1.8v
.ic V(Xdcim.Xcim11.W112)=0.0v
.ic V(Xdcim.Xcim11.W113)=1.8v
.ic V(Xdcim.Xcim11.W120)=0.0v
.ic V(Xdcim.Xcim11.W121)=1.8v
.ic V(Xdcim.Xcim11.W122)=0.0v
.ic V(Xdcim.Xcim11.W123)=1.8v
.ic V(Xdcim.Xcim11.W130)=0.0v
.ic V(Xdcim.Xcim11.W131)=1.8v
.ic V(Xdcim.Xcim11.W132)=0.0v
.ic V(Xdcim.Xcim11.W133)=1.8v
.ic V(Xdcim.Xcim11.W140)=0.0v
.ic V(Xdcim.Xcim11.W141)=1.8v
.ic V(Xdcim.Xcim11.W142)=0.0v
.ic V(Xdcim.Xcim11.W143)=1.8v
.ic V(Xdcim.Xcim11.W150)=0.0v
.ic V(Xdcim.Xcim11.W151)=1.8v
.ic V(Xdcim.Xcim11.W152)=0.0v
.ic V(Xdcim.Xcim11.W153)=1.8v
.ic V(Xdcim.Xcim11.W160)=0.0v
.ic V(Xdcim.Xcim11.W161)=1.8v
.ic V(Xdcim.Xcim11.W162)=0.0v
.ic V(Xdcim.Xcim11.W163)=1.8v
.ic V(Xdcim.Xcim11.W170)=0.0v
.ic V(Xdcim.Xcim11.W171)=1.8v
.ic V(Xdcim.Xcim11.W172)=0.0v
.ic V(Xdcim.Xcim11.W173)=1.8v
.ic V(Xdcim.Xcim11.W180)=0.0v
.ic V(Xdcim.Xcim11.W181)=1.8v
.ic V(Xdcim.Xcim11.W182)=0.0v
.ic V(Xdcim.Xcim11.W183)=1.8v
.ic V(Xdcim.Xcim11.W190)=0.0v
.ic V(Xdcim.Xcim11.W191)=1.8v
.ic V(Xdcim.Xcim11.W192)=0.0v
.ic V(Xdcim.Xcim11.W193)=1.8v
.ic V(Xdcim.Xcim11.W200)=0.0v
.ic V(Xdcim.Xcim11.W201)=1.8v
.ic V(Xdcim.Xcim11.W202)=0.0v
.ic V(Xdcim.Xcim11.W203)=1.8v
.ic V(Xdcim.Xcim11.W210)=0.0v
.ic V(Xdcim.Xcim11.W211)=1.8v
.ic V(Xdcim.Xcim11.W212)=0.0v
.ic V(Xdcim.Xcim11.W213)=1.8v
.ic V(Xdcim.Xcim11.W220)=0.0v
.ic V(Xdcim.Xcim11.W221)=1.8v
.ic V(Xdcim.Xcim11.W222)=0.0v
.ic V(Xdcim.Xcim11.W223)=1.8v
.ic V(Xdcim.Xcim11.W230)=0.0v
.ic V(Xdcim.Xcim11.W231)=1.8v
.ic V(Xdcim.Xcim11.W232)=0.0v
.ic V(Xdcim.Xcim11.W233)=1.8v
.ic V(Xdcim.Xcim11.W240)=0.0v
.ic V(Xdcim.Xcim11.W241)=1.8v
.ic V(Xdcim.Xcim11.W242)=0.0v
.ic V(Xdcim.Xcim11.W243)=1.8v
.ic V(Xdcim.Xcim11.W250)=0.0v
.ic V(Xdcim.Xcim11.W251)=1.8v
.ic V(Xdcim.Xcim11.W252)=0.0v
.ic V(Xdcim.Xcim11.W253)=1.8v
.ic V(Xdcim.Xcim11.W260)=0.0v
.ic V(Xdcim.Xcim11.W261)=1.8v
.ic V(Xdcim.Xcim11.W262)=0.0v
.ic V(Xdcim.Xcim11.W263)=1.8v
.ic V(Xdcim.Xcim11.W270)=0.0v
.ic V(Xdcim.Xcim11.W271)=1.8v
.ic V(Xdcim.Xcim11.W272)=0.0v
.ic V(Xdcim.Xcim11.W273)=1.8v
.ic V(Xdcim.Xcim11.W280)=0.0v
.ic V(Xdcim.Xcim11.W281)=1.8v
.ic V(Xdcim.Xcim11.W282)=0.0v
.ic V(Xdcim.Xcim11.W283)=1.8v
.ic V(Xdcim.Xcim11.W290)=0.0v
.ic V(Xdcim.Xcim11.W291)=1.8v
.ic V(Xdcim.Xcim11.W292)=0.0v
.ic V(Xdcim.Xcim11.W293)=1.8v
.ic V(Xdcim.Xcim11.W300)=0.0v
.ic V(Xdcim.Xcim11.W301)=1.8v
.ic V(Xdcim.Xcim11.W302)=0.0v
.ic V(Xdcim.Xcim11.W303)=1.8v
.ic V(Xdcim.Xcim11.W310)=0.0v
.ic V(Xdcim.Xcim11.W311)=1.8v
.ic V(Xdcim.Xcim11.W312)=0.0v
.ic V(Xdcim.Xcim11.W313)=1.8v
.ic V(Xdcim.Xcim11.W320)=0.0v
.ic V(Xdcim.Xcim11.W321)=1.8v
.ic V(Xdcim.Xcim11.W322)=0.0v
.ic V(Xdcim.Xcim11.W323)=1.8v
.ic V(Xdcim.Xcim12.W10)=1.8v
.ic V(Xdcim.Xcim12.W11)=1.8v
.ic V(Xdcim.Xcim12.W12)=0.0v
.ic V(Xdcim.Xcim12.W13)=1.8v
.ic V(Xdcim.Xcim12.W20)=1.8v
.ic V(Xdcim.Xcim12.W21)=1.8v
.ic V(Xdcim.Xcim12.W22)=0.0v
.ic V(Xdcim.Xcim12.W23)=1.8v
.ic V(Xdcim.Xcim12.W30)=1.8v
.ic V(Xdcim.Xcim12.W31)=1.8v
.ic V(Xdcim.Xcim12.W32)=0.0v
.ic V(Xdcim.Xcim12.W33)=1.8v
.ic V(Xdcim.Xcim12.W40)=1.8v
.ic V(Xdcim.Xcim12.W41)=1.8v
.ic V(Xdcim.Xcim12.W42)=0.0v
.ic V(Xdcim.Xcim12.W43)=1.8v
.ic V(Xdcim.Xcim12.W50)=1.8v
.ic V(Xdcim.Xcim12.W51)=1.8v
.ic V(Xdcim.Xcim12.W52)=0.0v
.ic V(Xdcim.Xcim12.W53)=1.8v
.ic V(Xdcim.Xcim12.W60)=1.8v
.ic V(Xdcim.Xcim12.W61)=1.8v
.ic V(Xdcim.Xcim12.W62)=0.0v
.ic V(Xdcim.Xcim12.W63)=1.8v
.ic V(Xdcim.Xcim12.W70)=1.8v
.ic V(Xdcim.Xcim12.W71)=1.8v
.ic V(Xdcim.Xcim12.W72)=0.0v
.ic V(Xdcim.Xcim12.W73)=1.8v
.ic V(Xdcim.Xcim12.W80)=1.8v
.ic V(Xdcim.Xcim12.W81)=1.8v
.ic V(Xdcim.Xcim12.W82)=0.0v
.ic V(Xdcim.Xcim12.W83)=1.8v
.ic V(Xdcim.Xcim12.W90)=1.8v
.ic V(Xdcim.Xcim12.W91)=1.8v
.ic V(Xdcim.Xcim12.W92)=0.0v
.ic V(Xdcim.Xcim12.W93)=1.8v
.ic V(Xdcim.Xcim12.W100)=1.8v
.ic V(Xdcim.Xcim12.W101)=1.8v
.ic V(Xdcim.Xcim12.W102)=0.0v
.ic V(Xdcim.Xcim12.W103)=1.8v
.ic V(Xdcim.Xcim12.W110)=1.8v
.ic V(Xdcim.Xcim12.W111)=1.8v
.ic V(Xdcim.Xcim12.W112)=0.0v
.ic V(Xdcim.Xcim12.W113)=1.8v
.ic V(Xdcim.Xcim12.W120)=1.8v
.ic V(Xdcim.Xcim12.W121)=1.8v
.ic V(Xdcim.Xcim12.W122)=0.0v
.ic V(Xdcim.Xcim12.W123)=1.8v
.ic V(Xdcim.Xcim12.W130)=1.8v
.ic V(Xdcim.Xcim12.W131)=1.8v
.ic V(Xdcim.Xcim12.W132)=0.0v
.ic V(Xdcim.Xcim12.W133)=1.8v
.ic V(Xdcim.Xcim12.W140)=1.8v
.ic V(Xdcim.Xcim12.W141)=1.8v
.ic V(Xdcim.Xcim12.W142)=0.0v
.ic V(Xdcim.Xcim12.W143)=1.8v
.ic V(Xdcim.Xcim12.W150)=1.8v
.ic V(Xdcim.Xcim12.W151)=1.8v
.ic V(Xdcim.Xcim12.W152)=0.0v
.ic V(Xdcim.Xcim12.W153)=1.8v
.ic V(Xdcim.Xcim12.W160)=1.8v
.ic V(Xdcim.Xcim12.W161)=1.8v
.ic V(Xdcim.Xcim12.W162)=0.0v
.ic V(Xdcim.Xcim12.W163)=1.8v
.ic V(Xdcim.Xcim12.W170)=1.8v
.ic V(Xdcim.Xcim12.W171)=1.8v
.ic V(Xdcim.Xcim12.W172)=0.0v
.ic V(Xdcim.Xcim12.W173)=1.8v
.ic V(Xdcim.Xcim12.W180)=1.8v
.ic V(Xdcim.Xcim12.W181)=1.8v
.ic V(Xdcim.Xcim12.W182)=0.0v
.ic V(Xdcim.Xcim12.W183)=1.8v
.ic V(Xdcim.Xcim12.W190)=1.8v
.ic V(Xdcim.Xcim12.W191)=1.8v
.ic V(Xdcim.Xcim12.W192)=0.0v
.ic V(Xdcim.Xcim12.W193)=1.8v
.ic V(Xdcim.Xcim12.W200)=1.8v
.ic V(Xdcim.Xcim12.W201)=1.8v
.ic V(Xdcim.Xcim12.W202)=0.0v
.ic V(Xdcim.Xcim12.W203)=1.8v
.ic V(Xdcim.Xcim12.W210)=1.8v
.ic V(Xdcim.Xcim12.W211)=1.8v
.ic V(Xdcim.Xcim12.W212)=0.0v
.ic V(Xdcim.Xcim12.W213)=1.8v
.ic V(Xdcim.Xcim12.W220)=1.8v
.ic V(Xdcim.Xcim12.W221)=1.8v
.ic V(Xdcim.Xcim12.W222)=0.0v
.ic V(Xdcim.Xcim12.W223)=1.8v
.ic V(Xdcim.Xcim12.W230)=1.8v
.ic V(Xdcim.Xcim12.W231)=1.8v
.ic V(Xdcim.Xcim12.W232)=0.0v
.ic V(Xdcim.Xcim12.W233)=1.8v
.ic V(Xdcim.Xcim12.W240)=1.8v
.ic V(Xdcim.Xcim12.W241)=1.8v
.ic V(Xdcim.Xcim12.W242)=0.0v
.ic V(Xdcim.Xcim12.W243)=1.8v
.ic V(Xdcim.Xcim12.W250)=1.8v
.ic V(Xdcim.Xcim12.W251)=1.8v
.ic V(Xdcim.Xcim12.W252)=0.0v
.ic V(Xdcim.Xcim12.W253)=1.8v
.ic V(Xdcim.Xcim12.W260)=1.8v
.ic V(Xdcim.Xcim12.W261)=1.8v
.ic V(Xdcim.Xcim12.W262)=0.0v
.ic V(Xdcim.Xcim12.W263)=1.8v
.ic V(Xdcim.Xcim12.W270)=1.8v
.ic V(Xdcim.Xcim12.W271)=1.8v
.ic V(Xdcim.Xcim12.W272)=0.0v
.ic V(Xdcim.Xcim12.W273)=1.8v
.ic V(Xdcim.Xcim12.W280)=1.8v
.ic V(Xdcim.Xcim12.W281)=1.8v
.ic V(Xdcim.Xcim12.W282)=0.0v
.ic V(Xdcim.Xcim12.W283)=1.8v
.ic V(Xdcim.Xcim12.W290)=1.8v
.ic V(Xdcim.Xcim12.W291)=1.8v
.ic V(Xdcim.Xcim12.W292)=0.0v
.ic V(Xdcim.Xcim12.W293)=1.8v
.ic V(Xdcim.Xcim12.W300)=1.8v
.ic V(Xdcim.Xcim12.W301)=1.8v
.ic V(Xdcim.Xcim12.W302)=0.0v
.ic V(Xdcim.Xcim12.W303)=1.8v
.ic V(Xdcim.Xcim12.W310)=1.8v
.ic V(Xdcim.Xcim12.W311)=1.8v
.ic V(Xdcim.Xcim12.W312)=0.0v
.ic V(Xdcim.Xcim12.W313)=1.8v
.ic V(Xdcim.Xcim12.W320)=1.8v
.ic V(Xdcim.Xcim12.W321)=1.8v
.ic V(Xdcim.Xcim12.W322)=0.0v
.ic V(Xdcim.Xcim12.W323)=1.8v
.ic V(Xdcim.Xcim13.W10)=0.0v
.ic V(Xdcim.Xcim13.W11)=0.0v
.ic V(Xdcim.Xcim13.W12)=1.8v
.ic V(Xdcim.Xcim13.W13)=1.8v
.ic V(Xdcim.Xcim13.W20)=0.0v
.ic V(Xdcim.Xcim13.W21)=0.0v
.ic V(Xdcim.Xcim13.W22)=1.8v
.ic V(Xdcim.Xcim13.W23)=1.8v
.ic V(Xdcim.Xcim13.W30)=0.0v
.ic V(Xdcim.Xcim13.W31)=0.0v
.ic V(Xdcim.Xcim13.W32)=1.8v
.ic V(Xdcim.Xcim13.W33)=1.8v
.ic V(Xdcim.Xcim13.W40)=0.0v
.ic V(Xdcim.Xcim13.W41)=0.0v
.ic V(Xdcim.Xcim13.W42)=1.8v
.ic V(Xdcim.Xcim13.W43)=1.8v
.ic V(Xdcim.Xcim13.W50)=0.0v
.ic V(Xdcim.Xcim13.W51)=0.0v
.ic V(Xdcim.Xcim13.W52)=1.8v
.ic V(Xdcim.Xcim13.W53)=1.8v
.ic V(Xdcim.Xcim13.W60)=0.0v
.ic V(Xdcim.Xcim13.W61)=0.0v
.ic V(Xdcim.Xcim13.W62)=1.8v
.ic V(Xdcim.Xcim13.W63)=1.8v
.ic V(Xdcim.Xcim13.W70)=0.0v
.ic V(Xdcim.Xcim13.W71)=0.0v
.ic V(Xdcim.Xcim13.W72)=1.8v
.ic V(Xdcim.Xcim13.W73)=1.8v
.ic V(Xdcim.Xcim13.W80)=0.0v
.ic V(Xdcim.Xcim13.W81)=0.0v
.ic V(Xdcim.Xcim13.W82)=1.8v
.ic V(Xdcim.Xcim13.W83)=1.8v
.ic V(Xdcim.Xcim13.W90)=0.0v
.ic V(Xdcim.Xcim13.W91)=0.0v
.ic V(Xdcim.Xcim13.W92)=1.8v
.ic V(Xdcim.Xcim13.W93)=1.8v
.ic V(Xdcim.Xcim13.W100)=0.0v
.ic V(Xdcim.Xcim13.W101)=0.0v
.ic V(Xdcim.Xcim13.W102)=1.8v
.ic V(Xdcim.Xcim13.W103)=1.8v
.ic V(Xdcim.Xcim13.W110)=0.0v
.ic V(Xdcim.Xcim13.W111)=0.0v
.ic V(Xdcim.Xcim13.W112)=1.8v
.ic V(Xdcim.Xcim13.W113)=1.8v
.ic V(Xdcim.Xcim13.W120)=0.0v
.ic V(Xdcim.Xcim13.W121)=0.0v
.ic V(Xdcim.Xcim13.W122)=1.8v
.ic V(Xdcim.Xcim13.W123)=1.8v
.ic V(Xdcim.Xcim13.W130)=0.0v
.ic V(Xdcim.Xcim13.W131)=0.0v
.ic V(Xdcim.Xcim13.W132)=1.8v
.ic V(Xdcim.Xcim13.W133)=1.8v
.ic V(Xdcim.Xcim13.W140)=0.0v
.ic V(Xdcim.Xcim13.W141)=0.0v
.ic V(Xdcim.Xcim13.W142)=1.8v
.ic V(Xdcim.Xcim13.W143)=1.8v
.ic V(Xdcim.Xcim13.W150)=0.0v
.ic V(Xdcim.Xcim13.W151)=0.0v
.ic V(Xdcim.Xcim13.W152)=1.8v
.ic V(Xdcim.Xcim13.W153)=1.8v
.ic V(Xdcim.Xcim13.W160)=0.0v
.ic V(Xdcim.Xcim13.W161)=0.0v
.ic V(Xdcim.Xcim13.W162)=1.8v
.ic V(Xdcim.Xcim13.W163)=1.8v
.ic V(Xdcim.Xcim13.W170)=0.0v
.ic V(Xdcim.Xcim13.W171)=0.0v
.ic V(Xdcim.Xcim13.W172)=1.8v
.ic V(Xdcim.Xcim13.W173)=1.8v
.ic V(Xdcim.Xcim13.W180)=0.0v
.ic V(Xdcim.Xcim13.W181)=0.0v
.ic V(Xdcim.Xcim13.W182)=1.8v
.ic V(Xdcim.Xcim13.W183)=1.8v
.ic V(Xdcim.Xcim13.W190)=0.0v
.ic V(Xdcim.Xcim13.W191)=0.0v
.ic V(Xdcim.Xcim13.W192)=1.8v
.ic V(Xdcim.Xcim13.W193)=1.8v
.ic V(Xdcim.Xcim13.W200)=0.0v
.ic V(Xdcim.Xcim13.W201)=0.0v
.ic V(Xdcim.Xcim13.W202)=1.8v
.ic V(Xdcim.Xcim13.W203)=1.8v
.ic V(Xdcim.Xcim13.W210)=0.0v
.ic V(Xdcim.Xcim13.W211)=0.0v
.ic V(Xdcim.Xcim13.W212)=1.8v
.ic V(Xdcim.Xcim13.W213)=1.8v
.ic V(Xdcim.Xcim13.W220)=0.0v
.ic V(Xdcim.Xcim13.W221)=0.0v
.ic V(Xdcim.Xcim13.W222)=1.8v
.ic V(Xdcim.Xcim13.W223)=1.8v
.ic V(Xdcim.Xcim13.W230)=0.0v
.ic V(Xdcim.Xcim13.W231)=0.0v
.ic V(Xdcim.Xcim13.W232)=1.8v
.ic V(Xdcim.Xcim13.W233)=1.8v
.ic V(Xdcim.Xcim13.W240)=0.0v
.ic V(Xdcim.Xcim13.W241)=0.0v
.ic V(Xdcim.Xcim13.W242)=1.8v
.ic V(Xdcim.Xcim13.W243)=1.8v
.ic V(Xdcim.Xcim13.W250)=0.0v
.ic V(Xdcim.Xcim13.W251)=0.0v
.ic V(Xdcim.Xcim13.W252)=1.8v
.ic V(Xdcim.Xcim13.W253)=1.8v
.ic V(Xdcim.Xcim13.W260)=0.0v
.ic V(Xdcim.Xcim13.W261)=0.0v
.ic V(Xdcim.Xcim13.W262)=1.8v
.ic V(Xdcim.Xcim13.W263)=1.8v
.ic V(Xdcim.Xcim13.W270)=0.0v
.ic V(Xdcim.Xcim13.W271)=0.0v
.ic V(Xdcim.Xcim13.W272)=1.8v
.ic V(Xdcim.Xcim13.W273)=1.8v
.ic V(Xdcim.Xcim13.W280)=0.0v
.ic V(Xdcim.Xcim13.W281)=0.0v
.ic V(Xdcim.Xcim13.W282)=1.8v
.ic V(Xdcim.Xcim13.W283)=1.8v
.ic V(Xdcim.Xcim13.W290)=0.0v
.ic V(Xdcim.Xcim13.W291)=0.0v
.ic V(Xdcim.Xcim13.W292)=1.8v
.ic V(Xdcim.Xcim13.W293)=1.8v
.ic V(Xdcim.Xcim13.W300)=0.0v
.ic V(Xdcim.Xcim13.W301)=0.0v
.ic V(Xdcim.Xcim13.W302)=1.8v
.ic V(Xdcim.Xcim13.W303)=1.8v
.ic V(Xdcim.Xcim13.W310)=0.0v
.ic V(Xdcim.Xcim13.W311)=0.0v
.ic V(Xdcim.Xcim13.W312)=1.8v
.ic V(Xdcim.Xcim13.W313)=1.8v
.ic V(Xdcim.Xcim13.W320)=0.0v
.ic V(Xdcim.Xcim13.W321)=0.0v
.ic V(Xdcim.Xcim13.W322)=1.8v
.ic V(Xdcim.Xcim13.W323)=1.8v
.ic V(Xdcim.Xcim14.W10)=1.8v
.ic V(Xdcim.Xcim14.W11)=0.0v
.ic V(Xdcim.Xcim14.W12)=1.8v
.ic V(Xdcim.Xcim14.W13)=1.8v
.ic V(Xdcim.Xcim14.W20)=1.8v
.ic V(Xdcim.Xcim14.W21)=0.0v
.ic V(Xdcim.Xcim14.W22)=1.8v
.ic V(Xdcim.Xcim14.W23)=1.8v
.ic V(Xdcim.Xcim14.W30)=1.8v
.ic V(Xdcim.Xcim14.W31)=0.0v
.ic V(Xdcim.Xcim14.W32)=1.8v
.ic V(Xdcim.Xcim14.W33)=1.8v
.ic V(Xdcim.Xcim14.W40)=1.8v
.ic V(Xdcim.Xcim14.W41)=0.0v
.ic V(Xdcim.Xcim14.W42)=1.8v
.ic V(Xdcim.Xcim14.W43)=1.8v
.ic V(Xdcim.Xcim14.W50)=1.8v
.ic V(Xdcim.Xcim14.W51)=0.0v
.ic V(Xdcim.Xcim14.W52)=1.8v
.ic V(Xdcim.Xcim14.W53)=1.8v
.ic V(Xdcim.Xcim14.W60)=1.8v
.ic V(Xdcim.Xcim14.W61)=0.0v
.ic V(Xdcim.Xcim14.W62)=1.8v
.ic V(Xdcim.Xcim14.W63)=1.8v
.ic V(Xdcim.Xcim14.W70)=1.8v
.ic V(Xdcim.Xcim14.W71)=0.0v
.ic V(Xdcim.Xcim14.W72)=1.8v
.ic V(Xdcim.Xcim14.W73)=1.8v
.ic V(Xdcim.Xcim14.W80)=1.8v
.ic V(Xdcim.Xcim14.W81)=0.0v
.ic V(Xdcim.Xcim14.W82)=1.8v
.ic V(Xdcim.Xcim14.W83)=1.8v
.ic V(Xdcim.Xcim14.W90)=1.8v
.ic V(Xdcim.Xcim14.W91)=0.0v
.ic V(Xdcim.Xcim14.W92)=1.8v
.ic V(Xdcim.Xcim14.W93)=1.8v
.ic V(Xdcim.Xcim14.W100)=1.8v
.ic V(Xdcim.Xcim14.W101)=0.0v
.ic V(Xdcim.Xcim14.W102)=1.8v
.ic V(Xdcim.Xcim14.W103)=1.8v
.ic V(Xdcim.Xcim14.W110)=1.8v
.ic V(Xdcim.Xcim14.W111)=0.0v
.ic V(Xdcim.Xcim14.W112)=1.8v
.ic V(Xdcim.Xcim14.W113)=1.8v
.ic V(Xdcim.Xcim14.W120)=1.8v
.ic V(Xdcim.Xcim14.W121)=0.0v
.ic V(Xdcim.Xcim14.W122)=1.8v
.ic V(Xdcim.Xcim14.W123)=1.8v
.ic V(Xdcim.Xcim14.W130)=1.8v
.ic V(Xdcim.Xcim14.W131)=0.0v
.ic V(Xdcim.Xcim14.W132)=1.8v
.ic V(Xdcim.Xcim14.W133)=1.8v
.ic V(Xdcim.Xcim14.W140)=1.8v
.ic V(Xdcim.Xcim14.W141)=0.0v
.ic V(Xdcim.Xcim14.W142)=1.8v
.ic V(Xdcim.Xcim14.W143)=1.8v
.ic V(Xdcim.Xcim14.W150)=1.8v
.ic V(Xdcim.Xcim14.W151)=0.0v
.ic V(Xdcim.Xcim14.W152)=1.8v
.ic V(Xdcim.Xcim14.W153)=1.8v
.ic V(Xdcim.Xcim14.W160)=1.8v
.ic V(Xdcim.Xcim14.W161)=0.0v
.ic V(Xdcim.Xcim14.W162)=1.8v
.ic V(Xdcim.Xcim14.W163)=1.8v
.ic V(Xdcim.Xcim14.W170)=1.8v
.ic V(Xdcim.Xcim14.W171)=0.0v
.ic V(Xdcim.Xcim14.W172)=1.8v
.ic V(Xdcim.Xcim14.W173)=1.8v
.ic V(Xdcim.Xcim14.W180)=1.8v
.ic V(Xdcim.Xcim14.W181)=0.0v
.ic V(Xdcim.Xcim14.W182)=1.8v
.ic V(Xdcim.Xcim14.W183)=1.8v
.ic V(Xdcim.Xcim14.W190)=1.8v
.ic V(Xdcim.Xcim14.W191)=0.0v
.ic V(Xdcim.Xcim14.W192)=1.8v
.ic V(Xdcim.Xcim14.W193)=1.8v
.ic V(Xdcim.Xcim14.W200)=1.8v
.ic V(Xdcim.Xcim14.W201)=0.0v
.ic V(Xdcim.Xcim14.W202)=1.8v
.ic V(Xdcim.Xcim14.W203)=1.8v
.ic V(Xdcim.Xcim14.W210)=1.8v
.ic V(Xdcim.Xcim14.W211)=0.0v
.ic V(Xdcim.Xcim14.W212)=1.8v
.ic V(Xdcim.Xcim14.W213)=1.8v
.ic V(Xdcim.Xcim14.W220)=1.8v
.ic V(Xdcim.Xcim14.W221)=0.0v
.ic V(Xdcim.Xcim14.W222)=1.8v
.ic V(Xdcim.Xcim14.W223)=1.8v
.ic V(Xdcim.Xcim14.W230)=1.8v
.ic V(Xdcim.Xcim14.W231)=0.0v
.ic V(Xdcim.Xcim14.W232)=1.8v
.ic V(Xdcim.Xcim14.W233)=1.8v
.ic V(Xdcim.Xcim14.W240)=1.8v
.ic V(Xdcim.Xcim14.W241)=0.0v
.ic V(Xdcim.Xcim14.W242)=1.8v
.ic V(Xdcim.Xcim14.W243)=1.8v
.ic V(Xdcim.Xcim14.W250)=1.8v
.ic V(Xdcim.Xcim14.W251)=0.0v
.ic V(Xdcim.Xcim14.W252)=1.8v
.ic V(Xdcim.Xcim14.W253)=1.8v
.ic V(Xdcim.Xcim14.W260)=1.8v
.ic V(Xdcim.Xcim14.W261)=0.0v
.ic V(Xdcim.Xcim14.W262)=1.8v
.ic V(Xdcim.Xcim14.W263)=1.8v
.ic V(Xdcim.Xcim14.W270)=1.8v
.ic V(Xdcim.Xcim14.W271)=0.0v
.ic V(Xdcim.Xcim14.W272)=1.8v
.ic V(Xdcim.Xcim14.W273)=1.8v
.ic V(Xdcim.Xcim14.W280)=1.8v
.ic V(Xdcim.Xcim14.W281)=0.0v
.ic V(Xdcim.Xcim14.W282)=1.8v
.ic V(Xdcim.Xcim14.W283)=1.8v
.ic V(Xdcim.Xcim14.W290)=1.8v
.ic V(Xdcim.Xcim14.W291)=0.0v
.ic V(Xdcim.Xcim14.W292)=1.8v
.ic V(Xdcim.Xcim14.W293)=1.8v
.ic V(Xdcim.Xcim14.W300)=1.8v
.ic V(Xdcim.Xcim14.W301)=0.0v
.ic V(Xdcim.Xcim14.W302)=1.8v
.ic V(Xdcim.Xcim14.W303)=1.8v
.ic V(Xdcim.Xcim14.W310)=1.8v
.ic V(Xdcim.Xcim14.W311)=0.0v
.ic V(Xdcim.Xcim14.W312)=1.8v
.ic V(Xdcim.Xcim14.W313)=1.8v
.ic V(Xdcim.Xcim14.W320)=1.8v
.ic V(Xdcim.Xcim14.W321)=0.0v
.ic V(Xdcim.Xcim14.W322)=1.8v
.ic V(Xdcim.Xcim14.W323)=1.8v
.ic V(Xdcim.Xcim15.W10)=0.0v
.ic V(Xdcim.Xcim15.W11)=1.8v
.ic V(Xdcim.Xcim15.W12)=1.8v
.ic V(Xdcim.Xcim15.W13)=1.8v
.ic V(Xdcim.Xcim15.W20)=0.0v
.ic V(Xdcim.Xcim15.W21)=1.8v
.ic V(Xdcim.Xcim15.W22)=1.8v
.ic V(Xdcim.Xcim15.W23)=1.8v
.ic V(Xdcim.Xcim15.W30)=0.0v
.ic V(Xdcim.Xcim15.W31)=1.8v
.ic V(Xdcim.Xcim15.W32)=1.8v
.ic V(Xdcim.Xcim15.W33)=1.8v
.ic V(Xdcim.Xcim15.W40)=0.0v
.ic V(Xdcim.Xcim15.W41)=1.8v
.ic V(Xdcim.Xcim15.W42)=1.8v
.ic V(Xdcim.Xcim15.W43)=1.8v
.ic V(Xdcim.Xcim15.W50)=0.0v
.ic V(Xdcim.Xcim15.W51)=1.8v
.ic V(Xdcim.Xcim15.W52)=1.8v
.ic V(Xdcim.Xcim15.W53)=1.8v
.ic V(Xdcim.Xcim15.W60)=0.0v
.ic V(Xdcim.Xcim15.W61)=1.8v
.ic V(Xdcim.Xcim15.W62)=1.8v
.ic V(Xdcim.Xcim15.W63)=1.8v
.ic V(Xdcim.Xcim15.W70)=0.0v
.ic V(Xdcim.Xcim15.W71)=1.8v
.ic V(Xdcim.Xcim15.W72)=1.8v
.ic V(Xdcim.Xcim15.W73)=1.8v
.ic V(Xdcim.Xcim15.W80)=0.0v
.ic V(Xdcim.Xcim15.W81)=1.8v
.ic V(Xdcim.Xcim15.W82)=1.8v
.ic V(Xdcim.Xcim15.W83)=1.8v
.ic V(Xdcim.Xcim15.W90)=0.0v
.ic V(Xdcim.Xcim15.W91)=1.8v
.ic V(Xdcim.Xcim15.W92)=1.8v
.ic V(Xdcim.Xcim15.W93)=1.8v
.ic V(Xdcim.Xcim15.W100)=0.0v
.ic V(Xdcim.Xcim15.W101)=1.8v
.ic V(Xdcim.Xcim15.W102)=1.8v
.ic V(Xdcim.Xcim15.W103)=1.8v
.ic V(Xdcim.Xcim15.W110)=0.0v
.ic V(Xdcim.Xcim15.W111)=1.8v
.ic V(Xdcim.Xcim15.W112)=1.8v
.ic V(Xdcim.Xcim15.W113)=1.8v
.ic V(Xdcim.Xcim15.W120)=0.0v
.ic V(Xdcim.Xcim15.W121)=1.8v
.ic V(Xdcim.Xcim15.W122)=1.8v
.ic V(Xdcim.Xcim15.W123)=1.8v
.ic V(Xdcim.Xcim15.W130)=0.0v
.ic V(Xdcim.Xcim15.W131)=1.8v
.ic V(Xdcim.Xcim15.W132)=1.8v
.ic V(Xdcim.Xcim15.W133)=1.8v
.ic V(Xdcim.Xcim15.W140)=0.0v
.ic V(Xdcim.Xcim15.W141)=1.8v
.ic V(Xdcim.Xcim15.W142)=1.8v
.ic V(Xdcim.Xcim15.W143)=1.8v
.ic V(Xdcim.Xcim15.W150)=0.0v
.ic V(Xdcim.Xcim15.W151)=1.8v
.ic V(Xdcim.Xcim15.W152)=1.8v
.ic V(Xdcim.Xcim15.W153)=1.8v
.ic V(Xdcim.Xcim15.W160)=0.0v
.ic V(Xdcim.Xcim15.W161)=1.8v
.ic V(Xdcim.Xcim15.W162)=1.8v
.ic V(Xdcim.Xcim15.W163)=1.8v
.ic V(Xdcim.Xcim15.W170)=0.0v
.ic V(Xdcim.Xcim15.W171)=1.8v
.ic V(Xdcim.Xcim15.W172)=1.8v
.ic V(Xdcim.Xcim15.W173)=1.8v
.ic V(Xdcim.Xcim15.W180)=0.0v
.ic V(Xdcim.Xcim15.W181)=1.8v
.ic V(Xdcim.Xcim15.W182)=1.8v
.ic V(Xdcim.Xcim15.W183)=1.8v
.ic V(Xdcim.Xcim15.W190)=0.0v
.ic V(Xdcim.Xcim15.W191)=1.8v
.ic V(Xdcim.Xcim15.W192)=1.8v
.ic V(Xdcim.Xcim15.W193)=1.8v
.ic V(Xdcim.Xcim15.W200)=0.0v
.ic V(Xdcim.Xcim15.W201)=1.8v
.ic V(Xdcim.Xcim15.W202)=1.8v
.ic V(Xdcim.Xcim15.W203)=1.8v
.ic V(Xdcim.Xcim15.W210)=0.0v
.ic V(Xdcim.Xcim15.W211)=1.8v
.ic V(Xdcim.Xcim15.W212)=1.8v
.ic V(Xdcim.Xcim15.W213)=1.8v
.ic V(Xdcim.Xcim15.W220)=0.0v
.ic V(Xdcim.Xcim15.W221)=1.8v
.ic V(Xdcim.Xcim15.W222)=1.8v
.ic V(Xdcim.Xcim15.W223)=1.8v
.ic V(Xdcim.Xcim15.W230)=0.0v
.ic V(Xdcim.Xcim15.W231)=1.8v
.ic V(Xdcim.Xcim15.W232)=1.8v
.ic V(Xdcim.Xcim15.W233)=1.8v
.ic V(Xdcim.Xcim15.W240)=0.0v
.ic V(Xdcim.Xcim15.W241)=1.8v
.ic V(Xdcim.Xcim15.W242)=1.8v
.ic V(Xdcim.Xcim15.W243)=1.8v
.ic V(Xdcim.Xcim15.W250)=0.0v
.ic V(Xdcim.Xcim15.W251)=1.8v
.ic V(Xdcim.Xcim15.W252)=1.8v
.ic V(Xdcim.Xcim15.W253)=1.8v
.ic V(Xdcim.Xcim15.W260)=0.0v
.ic V(Xdcim.Xcim15.W261)=1.8v
.ic V(Xdcim.Xcim15.W262)=1.8v
.ic V(Xdcim.Xcim15.W263)=1.8v
.ic V(Xdcim.Xcim15.W270)=0.0v
.ic V(Xdcim.Xcim15.W271)=1.8v
.ic V(Xdcim.Xcim15.W272)=1.8v
.ic V(Xdcim.Xcim15.W273)=1.8v
.ic V(Xdcim.Xcim15.W280)=0.0v
.ic V(Xdcim.Xcim15.W281)=1.8v
.ic V(Xdcim.Xcim15.W282)=1.8v
.ic V(Xdcim.Xcim15.W283)=1.8v
.ic V(Xdcim.Xcim15.W290)=0.0v
.ic V(Xdcim.Xcim15.W291)=1.8v
.ic V(Xdcim.Xcim15.W292)=1.8v
.ic V(Xdcim.Xcim15.W293)=1.8v
.ic V(Xdcim.Xcim15.W300)=0.0v
.ic V(Xdcim.Xcim15.W301)=1.8v
.ic V(Xdcim.Xcim15.W302)=1.8v
.ic V(Xdcim.Xcim15.W303)=1.8v
.ic V(Xdcim.Xcim15.W310)=0.0v
.ic V(Xdcim.Xcim15.W311)=1.8v
.ic V(Xdcim.Xcim15.W312)=1.8v
.ic V(Xdcim.Xcim15.W313)=1.8v
.ic V(Xdcim.Xcim15.W320)=0.0v
.ic V(Xdcim.Xcim15.W321)=1.8v
.ic V(Xdcim.Xcim15.W322)=1.8v
.ic V(Xdcim.Xcim15.W323)=1.8v
.ic V(Xdcim.Xcim16.W10)=1.8v
.ic V(Xdcim.Xcim16.W11)=1.8v
.ic V(Xdcim.Xcim16.W12)=1.8v
.ic V(Xdcim.Xcim16.W13)=1.8v
.ic V(Xdcim.Xcim16.W20)=1.8v
.ic V(Xdcim.Xcim16.W21)=1.8v
.ic V(Xdcim.Xcim16.W22)=1.8v
.ic V(Xdcim.Xcim16.W23)=1.8v
.ic V(Xdcim.Xcim16.W30)=1.8v
.ic V(Xdcim.Xcim16.W31)=1.8v
.ic V(Xdcim.Xcim16.W32)=1.8v
.ic V(Xdcim.Xcim16.W33)=1.8v
.ic V(Xdcim.Xcim16.W40)=1.8v
.ic V(Xdcim.Xcim16.W41)=1.8v
.ic V(Xdcim.Xcim16.W42)=1.8v
.ic V(Xdcim.Xcim16.W43)=1.8v
.ic V(Xdcim.Xcim16.W50)=1.8v
.ic V(Xdcim.Xcim16.W51)=1.8v
.ic V(Xdcim.Xcim16.W52)=1.8v
.ic V(Xdcim.Xcim16.W53)=1.8v
.ic V(Xdcim.Xcim16.W60)=1.8v
.ic V(Xdcim.Xcim16.W61)=1.8v
.ic V(Xdcim.Xcim16.W62)=1.8v
.ic V(Xdcim.Xcim16.W63)=1.8v
.ic V(Xdcim.Xcim16.W70)=1.8v
.ic V(Xdcim.Xcim16.W71)=1.8v
.ic V(Xdcim.Xcim16.W72)=1.8v
.ic V(Xdcim.Xcim16.W73)=1.8v
.ic V(Xdcim.Xcim16.W80)=1.8v
.ic V(Xdcim.Xcim16.W81)=1.8v
.ic V(Xdcim.Xcim16.W82)=1.8v
.ic V(Xdcim.Xcim16.W83)=1.8v
.ic V(Xdcim.Xcim16.W90)=1.8v
.ic V(Xdcim.Xcim16.W91)=1.8v
.ic V(Xdcim.Xcim16.W92)=1.8v
.ic V(Xdcim.Xcim16.W93)=1.8v
.ic V(Xdcim.Xcim16.W100)=1.8v
.ic V(Xdcim.Xcim16.W101)=1.8v
.ic V(Xdcim.Xcim16.W102)=1.8v
.ic V(Xdcim.Xcim16.W103)=1.8v
.ic V(Xdcim.Xcim16.W110)=1.8v
.ic V(Xdcim.Xcim16.W111)=1.8v
.ic V(Xdcim.Xcim16.W112)=1.8v
.ic V(Xdcim.Xcim16.W113)=1.8v
.ic V(Xdcim.Xcim16.W120)=1.8v
.ic V(Xdcim.Xcim16.W121)=1.8v
.ic V(Xdcim.Xcim16.W122)=1.8v
.ic V(Xdcim.Xcim16.W123)=1.8v
.ic V(Xdcim.Xcim16.W130)=1.8v
.ic V(Xdcim.Xcim16.W131)=1.8v
.ic V(Xdcim.Xcim16.W132)=1.8v
.ic V(Xdcim.Xcim16.W133)=1.8v
.ic V(Xdcim.Xcim16.W140)=1.8v
.ic V(Xdcim.Xcim16.W141)=1.8v
.ic V(Xdcim.Xcim16.W142)=1.8v
.ic V(Xdcim.Xcim16.W143)=1.8v
.ic V(Xdcim.Xcim16.W150)=1.8v
.ic V(Xdcim.Xcim16.W151)=1.8v
.ic V(Xdcim.Xcim16.W152)=1.8v
.ic V(Xdcim.Xcim16.W153)=1.8v
.ic V(Xdcim.Xcim16.W160)=1.8v
.ic V(Xdcim.Xcim16.W161)=1.8v
.ic V(Xdcim.Xcim16.W162)=1.8v
.ic V(Xdcim.Xcim16.W163)=1.8v
.ic V(Xdcim.Xcim16.W170)=1.8v
.ic V(Xdcim.Xcim16.W171)=1.8v
.ic V(Xdcim.Xcim16.W172)=1.8v
.ic V(Xdcim.Xcim16.W173)=1.8v
.ic V(Xdcim.Xcim16.W180)=1.8v
.ic V(Xdcim.Xcim16.W181)=1.8v
.ic V(Xdcim.Xcim16.W182)=1.8v
.ic V(Xdcim.Xcim16.W183)=1.8v
.ic V(Xdcim.Xcim16.W190)=1.8v
.ic V(Xdcim.Xcim16.W191)=1.8v
.ic V(Xdcim.Xcim16.W192)=1.8v
.ic V(Xdcim.Xcim16.W193)=1.8v
.ic V(Xdcim.Xcim16.W200)=1.8v
.ic V(Xdcim.Xcim16.W201)=1.8v
.ic V(Xdcim.Xcim16.W202)=1.8v
.ic V(Xdcim.Xcim16.W203)=1.8v
.ic V(Xdcim.Xcim16.W210)=1.8v
.ic V(Xdcim.Xcim16.W211)=1.8v
.ic V(Xdcim.Xcim16.W212)=1.8v
.ic V(Xdcim.Xcim16.W213)=1.8v
.ic V(Xdcim.Xcim16.W220)=1.8v
.ic V(Xdcim.Xcim16.W221)=1.8v
.ic V(Xdcim.Xcim16.W222)=1.8v
.ic V(Xdcim.Xcim16.W223)=1.8v
.ic V(Xdcim.Xcim16.W230)=1.8v
.ic V(Xdcim.Xcim16.W231)=1.8v
.ic V(Xdcim.Xcim16.W232)=1.8v
.ic V(Xdcim.Xcim16.W233)=1.8v
.ic V(Xdcim.Xcim16.W240)=1.8v
.ic V(Xdcim.Xcim16.W241)=1.8v
.ic V(Xdcim.Xcim16.W242)=1.8v
.ic V(Xdcim.Xcim16.W243)=1.8v
.ic V(Xdcim.Xcim16.W250)=1.8v
.ic V(Xdcim.Xcim16.W251)=1.8v
.ic V(Xdcim.Xcim16.W252)=1.8v
.ic V(Xdcim.Xcim16.W253)=1.8v
.ic V(Xdcim.Xcim16.W260)=1.8v
.ic V(Xdcim.Xcim16.W261)=1.8v
.ic V(Xdcim.Xcim16.W262)=1.8v
.ic V(Xdcim.Xcim16.W263)=1.8v
.ic V(Xdcim.Xcim16.W270)=1.8v
.ic V(Xdcim.Xcim16.W271)=1.8v
.ic V(Xdcim.Xcim16.W272)=1.8v
.ic V(Xdcim.Xcim16.W273)=1.8v
.ic V(Xdcim.Xcim16.W280)=1.8v
.ic V(Xdcim.Xcim16.W281)=1.8v
.ic V(Xdcim.Xcim16.W282)=1.8v
.ic V(Xdcim.Xcim16.W283)=1.8v
.ic V(Xdcim.Xcim16.W290)=1.8v
.ic V(Xdcim.Xcim16.W291)=1.8v
.ic V(Xdcim.Xcim16.W292)=1.8v
.ic V(Xdcim.Xcim16.W293)=1.8v
.ic V(Xdcim.Xcim16.W300)=1.8v
.ic V(Xdcim.Xcim16.W301)=1.8v
.ic V(Xdcim.Xcim16.W302)=1.8v
.ic V(Xdcim.Xcim16.W303)=1.8v
.ic V(Xdcim.Xcim16.W310)=1.8v
.ic V(Xdcim.Xcim16.W311)=1.8v
.ic V(Xdcim.Xcim16.W312)=1.8v
.ic V(Xdcim.Xcim16.W313)=1.8v
.ic V(Xdcim.Xcim16.W320)=1.8v
.ic V(Xdcim.Xcim16.W321)=1.8v
.ic V(Xdcim.Xcim16.W322)=1.8v
.ic V(Xdcim.Xcim16.W323)=1.8v

*****************
*** call cell ***
*****************
Xdcim I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 I13 I14 I15 I16 I17 I18 I19 I20 I21 I22 I23 I24 I25 I26 I27 I28 I29 I30 I31 I32 IN_VAL CLK RST O1_0 O1_1 O1_2 O1_3 O1_4 O1_5 O1_6 O1_7 O1_8 O1_9 O1_10 O1_11 O1_12 O2_0 O2_1 O2_2 O2_3 O2_4 O2_5 O2_6 O2_7 O2_8 O2_9 O2_10 O2_11 O2_12 O3_0 O3_1 O3_2 O3_3 O3_4 O3_5 O3_6 O3_7 O3_8 O3_9 O3_10 O3_11 O3_12 O4_0 O4_1 O4_2 O4_3 O4_4 O4_5 O4_6 O4_7 O4_8 O4_9 O4_10 O4_11 O4_12 O5_0 O5_1 O5_2 O5_3 O5_4 O5_5 O5_6 O5_7 O5_8 O5_9 O5_10 O5_11 O5_12 O6_0 O6_1 O6_2 O6_3 O6_4 O6_5 O6_6 O6_7 O6_8 O6_9 O6_10 O6_11 O6_12 O7_0 O7_1 O7_2 O7_3 O7_4 O7_5 O7_6 O7_7 O7_8 O7_9 O7_10 O7_11 O7_12 O8_0 O8_1 O8_2 O8_3 O8_4 O8_5 O8_6 O8_7 O8_8 O8_9 O8_10 O8_11 O8_12 O9_0 O9_1 O9_2 O9_3 O9_4 O9_5 O9_6 O9_7 O9_8 O9_9 O9_10 O9_11 O9_12 O10_0 O10_1 O10_2 O10_3 O10_4 O10_5 O10_6 O10_7 O10_8 O10_9 O10_10 O10_11 O10_12 O11_0 O11_1 O11_2 O11_3 O11_4 O11_5 O11_6 O11_7 O11_8 O11_9 O11_10 O11_11 O11_12 O12_0 O12_1 O12_2 O12_3 O12_4 O12_5 O12_6 O12_7 O12_8 O12_9 O12_10 O12_11 O12_12 O13_0 O13_1 O13_2 O13_3 O13_4 O13_5 O13_6 O13_7 O13_8 O13_9 O13_10 O13_11 O13_12 O14_0 O14_1 O14_2 O14_3 O14_4 O14_5 O14_6 O14_7 O14_8 O14_9 O14_10 O14_11 O14_12 O15_0 O15_1 O15_2 O15_3 O15_4 O15_5 O15_6 O15_7 O15_8 O15_9 O15_10 O15_11 O15_12 O16_0 O16_1 O16_2 O16_3 O16_4 O16_5 O16_6 O16_7 O16_8 O16_9 O16_10 O16_11 O16_12 OUT_VAL DCIM

******************
*** DCIM block ***
******************
.subckt DCIM I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 I13 I14 I15 I16 I17 I18 I19 I20 I21 I22 I23 I24 I25 I26 I27 I28 I29 I30 I31 I32 IN_VAL CLK RST O1_0 O1_1 O1_2 O1_3 O1_4 O1_5 O1_6 O1_7 O1_8 O1_9 O1_10 O1_11 O1_12 O2_0 O2_1 O2_2 O2_3 O2_4 O2_5 O2_6 O2_7 O2_8 O2_9 O2_10 O2_11 O2_12 O3_0 O3_1 O3_2 O3_3 O3_4 O3_5 O3_6 O3_7 O3_8 O3_9 O3_10 O3_11 O3_12 O4_0 O4_1 O4_2 O4_3 O4_4 O4_5 O4_6 O4_7 O4_8 O4_9 O4_10 O4_11 O4_12 O5_0 O5_1 O5_2 O5_3 O5_4 O5_5 O5_6 O5_7 O5_8 O5_9 O5_10 O5_11 O5_12 O6_0 O6_1 O6_2 O6_3 O6_4 O6_5 O6_6 O6_7 O6_8 O6_9 O6_10 O6_11 O6_12 O7_0 O7_1 O7_2 O7_3 O7_4 O7_5 O7_6 O7_7 O7_8 O7_9 O7_10 O7_11 O7_12 O8_0 O8_1 O8_2 O8_3 O8_4 O8_5 O8_6 O8_7 O8_8 O8_9 O8_10 O8_11 O8_12 O9_0 O9_1 O9_2 O9_3 O9_4 O9_5 O9_6 O9_7 O9_8 O9_9 O9_10 O9_11 O9_12 O10_0 O10_1 O10_2 O10_3 O10_4 O10_5 O10_6 O10_7 O10_8 O10_9 O10_10 O10_11 O10_12 O11_0 O11_1 O11_2 O11_3 O11_4 O11_5 O11_6 O11_7 O11_8 O11_9 O11_10 O11_11 O11_12 O12_0 O12_1 O12_2 O12_3 O12_4 O12_5 O12_6 O12_7 O12_8 O12_9 O12_10 O12_11 O12_12 O13_0 O13_1 O13_2 O13_3 O13_4 O13_5 O13_6 O13_7 O13_8 O13_9 O13_10 O13_11 O13_12 O14_0 O14_1 O14_2 O14_3 O14_4 O14_5 O14_6 O14_7 O14_8 O14_9 O14_10 O14_11 O14_12 O15_0 O15_1 O15_2 O15_3 O15_4 O15_5 O15_6 O15_7 O15_8 O15_9 O15_10 O15_11 O15_12 O16_0 O16_1 O16_2 O16_3 O16_4 O16_5 O16_6 O16_7 O16_8 O16_9 O16_10 O16_11 O16_12 OUT_VAL

** Your code **

Xcontrol_in I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 I13 I14 I15 I16 I17 I18 I19 I20 I21 I22 I23 I24 I25 I26 I27 I28 I29 I30 I31 I32 CLK IN_VAL ii1 ii2 ii3 ii4 ii5 ii6 ii7 ii8 ii9 ii10 ii11 ii12 ii13 ii14 ii15 ii16 ii17 ii18 ii19 ii20 ii21 ii22 ii23 ii24 ii25 ii26 ii27 ii28 ii29 ii30 ii31 ii32 CON_IN
Xbuf1_1 ii1 IN1_1to4 BUF
Xbuf1_2 ii1 IN1_5to8 BUF
Xbuf1_3 ii1 IN1_9to12 BUF
Xbuf1_4 ii1 IN1_13to16 BUF
Xbuf2_1 ii2 IN2_1to4 BUF
Xbuf2_2 ii2 IN2_5to8 BUF
Xbuf2_3 ii2 IN2_9to12 BUF
Xbuf2_4 ii2 IN2_13to16 BUF
Xbuf3_1 ii3 IN3_1to4 BUF
Xbuf3_2 ii3 IN3_5to8 BUF
Xbuf3_3 ii3 IN3_9to12 BUF
Xbuf3_4 ii3 IN3_13to16 BUF
Xbuf4_1 ii4 IN4_1to4 BUF
Xbuf4_2 ii4 IN4_5to8 BUF
Xbuf4_3 ii4 IN4_9to12 BUF
Xbuf4_4 ii4 IN4_13to16 BUF
Xbuf5_1 ii5 IN5_1to4 BUF
Xbuf5_2 ii5 IN5_5to8 BUF
Xbuf5_3 ii5 IN5_9to12 BUF
Xbuf5_4 ii5 IN5_13to16 BUF
Xbuf6_1 ii6 IN6_1to4 BUF
Xbuf6_2 ii6 IN6_5to8 BUF
Xbuf6_3 ii6 IN6_9to12 BUF
Xbuf6_4 ii6 IN6_13to16 BUF
Xbuf7_1 ii7 IN7_1to4 BUF
Xbuf7_2 ii7 IN7_5to8 BUF
Xbuf7_3 ii7 IN7_9to12 BUF
Xbuf7_4 ii7 IN7_13to16 BUF
Xbuf8_1 ii8 IN8_1to4 BUF
Xbuf8_2 ii8 IN8_5to8 BUF
Xbuf8_3 ii8 IN8_9to12 BUF
Xbuf8_4 ii8 IN8_13to16 BUF
Xbuf9_1 ii9 IN9_1to4 BUF
Xbuf9_2 ii9 IN9_5to8 BUF
Xbuf9_3 ii9 IN9_9to12 BUF
Xbuf9_4 ii9 IN9_13to16 BUF
Xbuf10_1 ii10 IN10_1to4 BUF
Xbuf10_2 ii10 IN10_5to8 BUF
Xbuf10_3 ii10 IN10_9to12 BUF
Xbuf10_4 ii10 IN10_13to16 BUF
Xbuf11_1 ii11 IN11_1to4 BUF
Xbuf11_2 ii11 IN11_5to8 BUF
Xbuf11_3 ii11 IN11_9to12 BUF
Xbuf11_4 ii11 IN11_13to16 BUF
Xbuf12_1 ii12 IN12_1to4 BUF
Xbuf12_2 ii12 IN12_5to8 BUF
Xbuf12_3 ii12 IN12_9to12 BUF
Xbuf12_4 ii12 IN12_13to16 BUF
Xbuf13_1 ii13 IN13_1to4 BUF
Xbuf13_2 ii13 IN13_5to8 BUF
Xbuf13_3 ii13 IN13_9to12 BUF
Xbuf13_4 ii13 IN13_13to16 BUF
Xbuf14_1 ii14 IN14_1to4 BUF
Xbuf14_2 ii14 IN14_5to8 BUF
Xbuf14_3 ii14 IN14_9to12 BUF
Xbuf14_4 ii14 IN14_13to16 BUF
Xbuf15_1 ii15 IN15_1to4 BUF
Xbuf15_2 ii15 IN15_5to8 BUF
Xbuf15_3 ii15 IN15_9to12 BUF
Xbuf15_4 ii15 IN15_13to16 BUF
Xbuf16_1 ii16 IN16_1to4 BUF
Xbuf16_2 ii16 IN16_5to8 BUF
Xbuf16_3 ii16 IN16_9to12 BUF
Xbuf16_4 ii16 IN16_13to16 BUF
Xbuf17_1 ii17 IN17_1to4 BUF
Xbuf17_2 ii17 IN17_5to8 BUF
Xbuf17_3 ii17 IN17_9to12 BUF
Xbuf17_4 ii17 IN17_13to16 BUF
Xbuf18_1 ii18 IN18_1to4 BUF
Xbuf18_2 ii18 IN18_5to8 BUF
Xbuf18_3 ii18 IN18_9to12 BUF
Xbuf18_4 ii18 IN18_13to16 BUF
Xbuf19_1 ii19 IN19_1to4 BUF
Xbuf19_2 ii19 IN19_5to8 BUF
Xbuf19_3 ii19 IN19_9to12 BUF
Xbuf19_4 ii19 IN19_13to16 BUF
Xbuf20_1 ii20 IN20_1to4 BUF
Xbuf20_2 ii20 IN20_5to8 BUF
Xbuf20_3 ii20 IN20_9to12 BUF
Xbuf20_4 ii20 IN20_13to16 BUF
Xbuf21_1 ii21 IN21_1to4 BUF
Xbuf21_2 ii21 IN21_5to8 BUF
Xbuf21_3 ii21 IN21_9to12 BUF
Xbuf21_4 ii21 IN21_13to16 BUF
Xbuf22_1 ii22 IN22_1to4 BUF
Xbuf22_2 ii22 IN22_5to8 BUF
Xbuf22_3 ii22 IN22_9to12 BUF
Xbuf22_4 ii22 IN22_13to16 BUF
Xbuf23_1 ii23 IN23_1to4 BUF
Xbuf23_2 ii23 IN23_5to8 BUF
Xbuf23_3 ii23 IN23_9to12 BUF
Xbuf23_4 ii23 IN23_13to16 BUF
Xbuf24_1 ii24 IN24_1to4 BUF
Xbuf24_2 ii24 IN24_5to8 BUF
Xbuf24_3 ii24 IN24_9to12 BUF
Xbuf24_4 ii24 IN24_13to16 BUF
Xbuf25_1 ii25 IN25_1to4 BUF
Xbuf25_2 ii25 IN25_5to8 BUF
Xbuf25_3 ii25 IN25_9to12 BUF
Xbuf25_4 ii25 IN25_13to16 BUF
Xbuf26_1 ii26 IN26_1to4 BUF
Xbuf26_2 ii26 IN26_5to8 BUF
Xbuf26_3 ii26 IN26_9to12 BUF
Xbuf26_4 ii26 IN26_13to16 BUF
Xbuf27_1 ii27 IN27_1to4 BUF
Xbuf27_2 ii27 IN27_5to8 BUF
Xbuf27_3 ii27 IN27_9to12 BUF
Xbuf27_4 ii27 IN27_13to16 BUF
Xbuf28_1 ii28 IN28_1to4 BUF
Xbuf28_2 ii28 IN28_5to8 BUF
Xbuf28_3 ii28 IN28_9to12 BUF
Xbuf28_4 ii28 IN28_13to16 BUF
Xbuf29_1 ii29 IN29_1to4 BUF
Xbuf29_2 ii29 IN29_5to8 BUF
Xbuf29_3 ii29 IN29_9to12 BUF
Xbuf29_4 ii29 IN29_13to16 BUF
Xbuf30_1 ii30 IN30_1to4 BUF
Xbuf30_2 ii30 IN30_5to8 BUF
Xbuf30_3 ii30 IN30_9to12 BUF
Xbuf30_4 ii30 IN30_13to16 BUF
Xbuf31_1 ii31 IN31_1to4 BUF
Xbuf31_2 ii31 IN31_5to8 BUF
Xbuf31_3 ii31 IN31_9to12 BUF
Xbuf31_4 ii31 IN31_13to16 BUF
Xbuf32_1 ii32 IN32_1to4 BUF
Xbuf32_2 ii32 IN32_5to8 BUF
Xbuf32_3 ii32 IN32_9to12 BUF
Xbuf32_4 ii32 IN32_13to16 BUF

Xcim1 IN1_1to4 IN2_1to4 IN3_1to4 IN4_1to4 IN5_1to4 IN6_1to4 IN7_1to4 IN8_1to4 IN9_1to4 IN10_1to4 IN11_1to4 IN12_1to4 IN13_1to4 IN14_1to4 IN15_1to4 IN16_1to4 IN17_1to4 IN18_1to4 IN19_1to4 IN20_1to4 IN21_1to4 IN22_1to4 IN23_1to4 IN24_1to4 IN25_1to4 IN26_1to4 IN27_1to4 IN28_1to4 IN29_1to4 IN30_1to4 IN31_1to4 IN32_1to4 P10 P11 P12 P13 P14 P15 P16 P17 P18 COMPUTE
Xcim2 IN1_1to4 IN2_1to4 IN3_1to4 IN4_1to4 IN5_1to4 IN6_1to4 IN7_1to4 IN8_1to4 IN9_1to4 IN10_1to4 IN11_1to4 IN12_1to4 IN13_1to4 IN14_1to4 IN15_1to4 IN16_1to4 IN17_1to4 IN18_1to4 IN19_1to4 IN20_1to4 IN21_1to4 IN22_1to4 IN23_1to4 IN24_1to4 IN25_1to4 IN26_1to4 IN27_1to4 IN28_1to4 IN29_1to4 IN30_1to4 IN31_1to4 IN32_1to4 P20 P21 P22 P23 P24 P25 P26 P27 P28 COMPUTE
Xcim3 IN1_1to4 IN2_1to4 IN3_1to4 IN4_1to4 IN5_1to4 IN6_1to4 IN7_1to4 IN8_1to4 IN9_1to4 IN10_1to4 IN11_1to4 IN12_1to4 IN13_1to4 IN14_1to4 IN15_1to4 IN16_1to4 IN17_1to4 IN18_1to4 IN19_1to4 IN20_1to4 IN21_1to4 IN22_1to4 IN23_1to4 IN24_1to4 IN25_1to4 IN26_1to4 IN27_1to4 IN28_1to4 IN29_1to4 IN30_1to4 IN31_1to4 IN32_1to4 P30 P31 P32 P33 P34 P35 P36 P37 P38 COMPUTE
Xcim4 IN1_1to4 IN2_1to4 IN3_1to4 IN4_1to4 IN5_1to4 IN6_1to4 IN7_1to4 IN8_1to4 IN9_1to4 IN10_1to4 IN11_1to4 IN12_1to4 IN13_1to4 IN14_1to4 IN15_1to4 IN16_1to4 IN17_1to4 IN18_1to4 IN19_1to4 IN20_1to4 IN21_1to4 IN22_1to4 IN23_1to4 IN24_1to4 IN25_1to4 IN26_1to4 IN27_1to4 IN28_1to4 IN29_1to4 IN30_1to4 IN31_1to4 IN32_1to4 P40 P41 P42 P43 P44 P45 P46 P47 P48 COMPUTE
Xcim5 IN1_5to8 IN2_5to8 IN3_5to8 IN4_5to8 IN5_5to8 IN6_5to8 IN7_5to8 IN8_5to8 IN9_5to8 IN10_5to8 IN11_5to8 IN12_5to8 IN13_5to8 IN14_5to8 IN15_5to8 IN16_5to8 IN17_5to8 IN18_5to8 IN19_5to8 IN20_5to8 IN21_5to8 IN22_5to8 IN23_5to8 IN24_5to8 IN25_5to8 IN26_5to8 IN27_5to8 IN28_5to8 IN29_5to8 IN30_5to8 IN31_5to8 IN32_5to8 P50 P51 P52 P53 P54 P55 P56 P57 P58 COMPUTE
Xcim6 IN1_5to8 IN2_5to8 IN3_5to8 IN4_5to8 IN5_5to8 IN6_5to8 IN7_5to8 IN8_5to8 IN9_5to8 IN10_5to8 IN11_5to8 IN12_5to8 IN13_5to8 IN14_5to8 IN15_5to8 IN16_5to8 IN17_5to8 IN18_5to8 IN19_5to8 IN20_5to8 IN21_5to8 IN22_5to8 IN23_5to8 IN24_5to8 IN25_5to8 IN26_5to8 IN27_5to8 IN28_5to8 IN29_5to8 IN30_5to8 IN31_5to8 IN32_5to8 P60 P61 P62 P63 P64 P65 P66 P67 P68 COMPUTE
Xcim7 IN1_5to8 IN2_5to8 IN3_5to8 IN4_5to8 IN5_5to8 IN6_5to8 IN7_5to8 IN8_5to8 IN9_5to8 IN10_5to8 IN11_5to8 IN12_5to8 IN13_5to8 IN14_5to8 IN15_5to8 IN16_5to8 IN17_5to8 IN18_5to8 IN19_5to8 IN20_5to8 IN21_5to8 IN22_5to8 IN23_5to8 IN24_5to8 IN25_5to8 IN26_5to8 IN27_5to8 IN28_5to8 IN29_5to8 IN30_5to8 IN31_5to8 IN32_5to8 P70 P71 P72 P73 P74 P75 P76 P77 P78 COMPUTE
Xcim8 IN1_5to8 IN2_5to8 IN3_5to8 IN4_5to8 IN5_5to8 IN6_5to8 IN7_5to8 IN8_5to8 IN9_5to8 IN10_5to8 IN11_5to8 IN12_5to8 IN13_5to8 IN14_5to8 IN15_5to8 IN16_5to8 IN17_5to8 IN18_5to8 IN19_5to8 IN20_5to8 IN21_5to8 IN22_5to8 IN23_5to8 IN24_5to8 IN25_5to8 IN26_5to8 IN27_5to8 IN28_5to8 IN29_5to8 IN30_5to8 IN31_5to8 IN32_5to8 P80 P81 P82 P83 P84 P85 P86 P87 P88 COMPUTE
Xcim9  IN1_9to12 IN2_9to12 IN3_9to12 IN4_9to12 IN5_9to12 IN6_9to12 IN7_9to12 IN8_9to12 IN9_9to12 IN10_9to12 IN11_9to12 IN12_9to12 IN13_9to12 IN14_9to12 IN15_9to12 IN16_9to12 IN17_9to12 IN18_9to12 IN19_9to12 IN20_9to12 IN21_9to12 IN22_9to12 IN23_9to12 IN24_9to12 IN25_9to12 IN26_9to12 IN27_9to12 IN28_9to12 IN29_9to12 IN30_9to12 IN31_9to12 IN32_9to12 P90 P91 P92 P93 P94 P95 P96 P97 P98 COMPUTE
Xcim10 IN1_9to12 IN2_9to12 IN3_9to12 IN4_9to12 IN5_9to12 IN6_9to12 IN7_9to12 IN8_9to12 IN9_9to12 IN10_9to12 IN11_9to12 IN12_9to12 IN13_9to12 IN14_9to12 IN15_9to12 IN16_9to12 IN17_9to12 IN18_9to12 IN19_9to12 IN20_9to12 IN21_9to12 IN22_9to12 IN23_9to12 IN24_9to12 IN25_9to12 IN26_9to12 IN27_9to12 IN28_9to12 IN29_9to12 IN30_9to12 IN31_9to12 IN32_9to12 P100 P101 P102 P103 P104 P105 P106 P107 P108 COMPUTE
Xcim11 IN1_9to12 IN2_9to12 IN3_9to12 IN4_9to12 IN5_9to12 IN6_9to12 IN7_9to12 IN8_9to12 IN9_9to12 IN10_9to12 IN11_9to12 IN12_9to12 IN13_9to12 IN14_9to12 IN15_9to12 IN16_9to12 IN17_9to12 IN18_9to12 IN19_9to12 IN20_9to12 IN21_9to12 IN22_9to12 IN23_9to12 IN24_9to12 IN25_9to12 IN26_9to12 IN27_9to12 IN28_9to12 IN29_9to12 IN30_9to12 IN31_9to12 IN32_9to12 P110 P111 P112 P113 P114 P115 P116 P117 P118 COMPUTE
Xcim12 IN1_9to12 IN2_9to12 IN3_9to12 IN4_9to12 IN5_9to12 IN6_9to12 IN7_9to12 IN8_9to12 IN9_9to12 IN10_9to12 IN11_9to12 IN12_9to12 IN13_9to12 IN14_9to12 IN15_9to12 IN16_9to12 IN17_9to12 IN18_9to12 IN19_9to12 IN20_9to12 IN21_9to12 IN22_9to12 IN23_9to12 IN24_9to12 IN25_9to12 IN26_9to12 IN27_9to12 IN28_9to12 IN29_9to12 IN30_9to12 IN31_9to12 IN32_9to12 P120 P121 P122 P123 P124 P125 P126 P127 P128 COMPUTE
Xcim13 IN1_13to16 IN2_13to16 IN3_13to16 IN4_13to16 IN5_13to16 IN6_13to16 IN7_13to16 IN8_13to16 IN9_13to16 IN10_13to16 IN11_13to16 IN12_13to16 IN13_13to16 IN14_13to16 IN15_13to16 IN16_13to16 IN17_13to16 IN18_13to16 IN19_13to16 IN20_13to16 IN21_13to16 IN22_13to16 IN23_13to16 IN24_13to16 IN25_13to16 IN26_13to16 IN27_13to16 IN28_13to16 IN29_13to16 IN30_13to16 IN31_13to16 IN32_13to16 P130 P131 P132 P133 P134 P135 P136 P137 P138 COMPUTE
Xcim14 IN1_13to16 IN2_13to16 IN3_13to16 IN4_13to16 IN5_13to16 IN6_13to16 IN7_13to16 IN8_13to16 IN9_13to16 IN10_13to16 IN11_13to16 IN12_13to16 IN13_13to16 IN14_13to16 IN15_13to16 IN16_13to16 IN17_13to16 IN18_13to16 IN19_13to16 IN20_13to16 IN21_13to16 IN22_13to16 IN23_13to16 IN24_13to16 IN25_13to16 IN26_13to16 IN27_13to16 IN28_13to16 IN29_13to16 IN30_13to16 IN31_13to16 IN32_13to16 P140 P141 P142 P143 P144 P145 P146 P147 P148 COMPUTE
Xcim15 IN1_13to16 IN2_13to16 IN3_13to16 IN4_13to16 IN5_13to16 IN6_13to16 IN7_13to16 IN8_13to16 IN9_13to16 IN10_13to16 IN11_13to16 IN12_13to16 IN13_13to16 IN14_13to16 IN15_13to16 IN16_13to16 IN17_13to16 IN18_13to16 IN19_13to16 IN20_13to16 IN21_13to16 IN22_13to16 IN23_13to16 IN24_13to16 IN25_13to16 IN26_13to16 IN27_13to16 IN28_13to16 IN29_13to16 IN30_13to16 IN31_13to16 IN32_13to16 P150 P151 P152 P153 P154 P155 P156 P157 P158 COMPUTE
Xcim16 IN1_13to16 IN2_13to16 IN3_13to16 IN4_13to16 IN5_13to16 IN6_13to16 IN7_13to16 IN8_13to16 IN9_13to16 IN10_13to16 IN11_13to16 IN12_13to16 IN13_13to16 IN14_13to16 IN15_13to16 IN16_13to16 IN17_13to16 IN18_13to16 IN19_13to16 IN20_13to16 IN21_13to16 IN22_13to16 IN23_13to16 IN24_13to16 IN25_13to16 IN26_13to16 IN27_13to16 IN28_13to16 IN29_13to16 IN30_13to16 IN31_13to16 IN32_13to16 P160 P161 P162 P163 P164 P165 P166 P167 P168 COMPUTE

Xcontrol_out1 P10 P11 P12 P13 P14 P15 P16 P17 P18 GND GND GND GND CLK RST O1_0 O1_1 O1_2 O1_3 O1_4 O1_5 O1_6 O1_7 O1_8 O1_9 O1_10 O1_11 O1_12 CON_OUT
Xcontrol_out2 P20 P21 P22 P23 P24 P25 P26 P27 P28 GND GND GND GND CLK RST O2_0 O2_1 O2_2 O2_3 O2_4 O2_5 O2_6 O2_7 O2_8 O2_9 O2_10 O2_11 O2_12 CON_OUT
Xcontrol_out3 P30 P31 P32 P33 P34 P35 P36 P37 P38 GND GND GND GND CLK RST O3_0 O3_1 O3_2 O3_3 O3_4 O3_5 O3_6 O3_7 O3_8 O3_9 O3_10 O3_11 O3_12 CON_OUT
Xcontrol_out4 P40 P41 P42 P43 P44 P45 P46 P47 P48 GND GND GND GND CLK RST O4_0 O4_1 O4_2 O4_3 O4_4 O4_5 O4_6 O4_7 O4_8 O4_9 O4_10 O4_11 O4_12 CON_OUT
Xcontrol_out5 P50 P51 P52 P53 P54 P55 P56 P57 P58 GND GND GND GND CLK RST O5_0 O5_1 O5_2 O5_3 O5_4 O5_5 O5_6 O5_7 O5_8 O5_9 O5_10 O5_11 O5_12 CON_OUT
Xcontrol_out6 P60 P61 P62 P63 P64 P65 P66 P67 P68 GND GND GND GND CLK RST O6_0 O6_1 O6_2 O6_3 O6_4 O6_5 O6_6 O6_7 O6_8 O6_9 O6_10 O6_11 O6_12 CON_OUT
Xcontrol_out7 P70 P71 P72 P73 P74 P75 P76 P77 P78 GND GND GND GND CLK RST O7_0 O7_1 O7_2 O7_3 O7_4 O7_5 O7_6 O7_7 O7_8 O7_9 O7_10 O7_11 O7_12 CON_OUT
Xcontrol_out8 P80 P81 P82 P83 P84 P85 P86 P87 P88 GND GND GND GND CLK RST O8_0 O8_1 O8_2 O8_3 O8_4 O8_5 O8_6 O8_7 O8_8 O8_9 O8_10 O8_11 O8_12 CON_OUT
Xcontrol_out9 P90 P91 P92 P93 P94 P95 P96 P97 P98 GND GND GND GND CLK RST O9_0 O9_1 O9_2 O9_3 O9_4 O9_5 O9_6 O9_7 O9_8 O9_9 O9_10 O9_11 O9_12 CON_OUT
Xcontrol_out10 P100 P101 P102 P103 P104 P105 P106 P107 P108 GND GND GND GND CLK RST O10_0 O10_1 O10_2 O10_3 O10_4 O10_5 O10_6 O10_7 O10_8 O10_9 O10_10 O10_11 O10_12 CON_OUT
Xcontrol_out11 P110 P111 P112 P113 P114 P115 P116 P117 P118 GND GND GND GND CLK RST O11_0 O11_1 O11_2 O11_3 O11_4 O11_5 O11_6 O11_7 O11_8 O11_9 O11_10 O11_11 O11_12 CON_OUT
Xcontrol_out12 P120 P121 P122 P123 P124 P125 P126 P127 P128 GND GND GND GND CLK RST O12_0 O12_1 O12_2 O12_3 O12_4 O12_5 O12_6 O12_7 O12_8 O12_9 O12_10 O12_11 O12_12 CON_OUT
Xcontrol_out13 P130 P131 P132 P133 P134 P135 P136 P137 P138 GND GND GND GND CLK RST O13_0 O13_1 O13_2 O13_3 O13_4 O13_5 O13_6 O13_7 O13_8 O13_9 O13_10 O13_11 O13_12 CON_OUT
Xcontrol_out14 P140 P141 P142 P143 P144 P145 P146 P147 P148 GND GND GND GND CLK RST O14_0 O14_1 O14_2 O14_3 O14_4 O14_5 O14_6 O14_7 O14_8 O14_9 O14_10 O14_11 O14_12 CON_OUT
Xcontrol_out15 P150 P151 P152 P153 P154 P155 P156 P157 P158 GND GND GND GND CLK RST O15_0 O15_1 O15_2 O15_3 O15_4 O15_5 O15_6 O15_7 O15_8 O15_9 O15_10 O15_11 O15_12 CON_OUT
Xcontrol_out16 P160 P161 P162 P163 P164 P165 P166 P167 P168 GND GND GND GND CLK RST O16_0 O16_1 O16_2 O16_3 O16_4 O16_5 O16_6 O16_7 O16_8 O16_9 O16_10 O16_11 O16_12 CON_OUT
Xdff1 IN_VAL CLK RST IN_VAL_T_1 IN_VAL_T_1_INV DFF
Xdff2 IN_VAL_T_1 CLK RST IN_VAL_T_2 IN_VAL_T_2_INV DFF
Xnor IN_VAL_T_1 IN_VAL_T_2_INV OUT_VAL NOR2
.ends

************************
*** input controller ***
************************
.subckt CON_IN I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 I13 I14 I15 I16 I17 I18 I19 I20 I21 I22 I23 I24 I25 I26 I27 I28 I29 I30 I31 I32 CLK ENB ii1 ii2 ii3 ii4 ii5 ii6 ii7 ii8 ii9 ii10 ii11 ii12 ii13 ii14 ii15 ii16 ii17 ii18 ii19 ii20 ii21 ii22 ii23 ii24 ii25 ii26 ii27 ii28 ii29 ii30 ii31 ii32
*** Your code ***
Xinv CLK CLK_INV INV
Xand1 I1 ENB N1 AND2
Xand2 I2 ENB N2 AND2
Xand3 I3 ENB N3 AND2
Xand4 I4 ENB N4 AND2
Xand5 I5 ENB N5 AND2
Xand6 I6 ENB N6 AND2
Xand7 I7 ENB N7 AND2
Xand8 I8 ENB N8 AND2
Xand9 I9 ENB N9 AND2
Xand10 I10 ENB N10 AND2
Xand11 I11 ENB N11 AND2
Xand12 I12 ENB N12 AND2
Xand13 I13 ENB N13 AND2
Xand14 I14 ENB N14 AND2
Xand15 I15 ENB N15 AND2
Xand16 I16 ENB N16 AND2
Xand17 I17 ENB N17 AND2
Xand18 I18 ENB N18 AND2
Xand19 I19 ENB N19 AND2
Xand20 I20 ENB N20 AND2
Xand21 I21 ENB N21 AND2
Xand22 I22 ENB N22 AND2
Xand23 I23 ENB N23 AND2
Xand24 I24 ENB N24 AND2
Xand25 I25 ENB N25 AND2
Xand26 I26 ENB N26 AND2
Xand27 I27 ENB N27 AND2
Xand28 I28 ENB N28 AND2
Xand29 I29 ENB N29 AND2
Xand30 I30 ENB N30 AND2
Xand31 I31 ENB N31 AND2
Xand32 I32 ENB N32 AND2
Xdlatch1_master N1 CLK Y1 Y1_INV DLATCH
Xdlatch1_slave Y1 CLK_INV ii1 ii1_INV DLATCH
Xdlatch2_master N2 CLK Y2 Y2_INV DLATCH
Xdlatch2_slave Y2 CLK_INV ii2 ii2_INV DLATCH
Xdlatch3_master N3 CLK Y3 Y3_INV DLATCH
Xdlatch3_slave Y3 CLK_INV ii3 ii3_INV DLATCH
Xdlatch4_master N4 CLK Y4 Y4_INV DLATCH
Xdlatch4_slave Y4 CLK_INV ii4 ii4_INV DLATCH
Xdlatch5_master N5 CLK Y5 Y5_INV DLATCH
Xdlatch5_slave Y5 CLK_INV ii5 ii5_INV DLATCH
Xdlatch6_master N6 CLK Y6 Y6_INV DLATCH
Xdlatch6_slave Y6 CLK_INV ii6 ii6_INV DLATCH
Xdlatch7_master N7 CLK Y7 Y7_INV DLATCH
Xdlatch7_slave Y7 CLK_INV ii7 ii7_INV DLATCH
Xdlatch8_master N8 CLK Y8 Y8_INV DLATCH
Xdlatch8_slave Y8 CLK_INV ii8 ii8_INV DLATCH
Xdlatch9_master N9 CLK Y9 Y9_INV DLATCH
Xdlatch9_slave Y9 CLK_INV ii9 ii9_INV DLATCH
Xdlatch10_master N10 CLK Y10 Y10_INV DLATCH
Xdlatch10_slave Y10 CLK_INV ii10 ii10_INV DLATCH
Xdlatch11_master N11 CLK Y11 Y11_INV DLATCH
Xdlatch11_slave Y11 CLK_INV ii11 ii11_INV DLATCH
Xdlatch12_master N12 CLK Y12 Y12_INV DLATCH
Xdlatch12_slave Y12 CLK_INV ii12 ii12_INV DLATCH
Xdlatch13_master N13 CLK Y13 Y13_INV DLATCH
Xdlatch13_slave Y13 CLK_INV ii13 ii13_INV DLATCH
Xdlatch14_master N14 CLK Y14 Y14_INV DLATCH
Xdlatch14_slave Y14 CLK_INV ii14 ii14_INV DLATCH
Xdlatch15_master N15 CLK Y15 Y15_INV DLATCH
Xdlatch15_slave Y15 CLK_INV ii15 ii15_INV DLATCH
Xdlatch16_master N16 CLK Y16 Y16_INV DLATCH
Xdlatch16_slave Y16 CLK_INV ii16 ii16_INV DLATCH
Xdlatch17_master N17 CLK Y17 Y17_INV DLATCH
Xdlatch17_slave Y17 CLK_INV ii17 ii17_INV DLATCH
Xdlatch18_master N18 CLK Y18 Y18_INV DLATCH
Xdlatch18_slave Y18 CLK_INV ii18 ii18_INV DLATCH
Xdlatch19_master N19 CLK Y19 Y19_INV DLATCH
Xdlatch19_slave Y19 CLK_INV ii19 ii19_INV DLATCH
Xdlatch20_master N20 CLK Y20 Y20_INV DLATCH
Xdlatch20_slave Y20 CLK_INV ii20 ii20_INV DLATCH
Xdlatch21_master N21 CLK Y21 Y21_INV DLATCH
Xdlatch21_slave Y21 CLK_INV ii21 ii21_INV DLATCH
Xdlatch22_master N22 CLK Y22 Y22_INV DLATCH
Xdlatch22_slave Y22 CLK_INV ii22 ii22_INV DLATCH
Xdlatch23_master N23 CLK Y23 Y23_INV DLATCH
Xdlatch23_slave Y23 CLK_INV ii23 ii23_INV DLATCH
Xdlatch24_master N24 CLK Y24 Y24_INV DLATCH
Xdlatch24_slave Y24 CLK_INV ii24 ii24_INV DLATCH
Xdlatch25_master N25 CLK Y25 Y25_INV DLATCH
Xdlatch25_slave Y25 CLK_INV ii25 ii25_INV DLATCH
Xdlatch26_master N26 CLK Y26 Y26_INV DLATCH
Xdlatch26_slave Y26 CLK_INV ii26 ii26_INV DLATCH
Xdlatch27_master N27 CLK Y27 Y27_INV DLATCH
Xdlatch27_slave Y27 CLK_INV ii27 ii27_INV DLATCH
Xdlatch28_master N28 CLK Y28 Y28_INV DLATCH
Xdlatch28_slave Y28 CLK_INV ii28 ii28_INV DLATCH
Xdlatch29_master N29 CLK Y29 Y29_INV DLATCH
Xdlatch29_slave Y29 CLK_INV ii29 ii29_INV DLATCH
Xdlatch30_master N30 CLK Y30 Y30_INV DLATCH
Xdlatch30_slave Y30 CLK_INV ii30 ii30_INV DLATCH
Xdlatch31_master N31 CLK Y31 Y31_INV DLATCH
Xdlatch31_slave Y31 CLK_INV ii31 ii31_INV DLATCH
Xdlatch32_master N32 CLK Y32 Y32_INV DLATCH
Xdlatch32_slave Y32 CLK_INV ii32 ii32_INV DLATCH
.ends

*************************
*** output controller ***
*************************
.subckt CON_OUT P0 P1 P2 P3 P4 P5 P6 P7 P8 P9 P10 P11 P12 CLK RST O0 O1 O2 O3 O4 O5 O6 O7 O8 O9 O10 O11 O12
*** Your code ***
Xadder12 GND P0 P1 P2 P3 P4 P5 P6 P7 P8 P9 P10 P11 GND S0 S1 S2 S3 S4 S5 S6 S7 S8 S9 S10 O0 O1 O2 O3 O4 O5 O6 O7 O8 O9 O10 O11 O12 ADDER12
Xreg13 O0 O1 O2 O3 O4 O5 O6 O7 O8 O9 O10 O11 O12 CLK RST S0 S1 S2 S3 S4 S5 S6 S7 S8 S9 S10 S11 S12 REG13
.ends

*******************
*** Your subckt ***
*******************

.subckt INV IN OUT
Mp1 OUT IN VDD VDD p_18 l=0.18u w=0.72u
Mn1 OUT IN GND GND n_18 l=0.18u w=0.36u
.ends

.subckt BUF IN OUT
Xinv1 IN INV INV
Xinv2 INV OUT INV
.ends

.subckt NOR2 IN1 IN2 OUT
Mp1 N1 IN1 VDD VDD p_18 l=0.18u w=0.72u
Mp2 OUT IN2 N1 VDD p_18 l=0.18u w=0.72u
Mn1 OUT IN1 GND GND n_18 l=0.18u w=0.36u
Mn2 OUT IN2 GND GND n_18 l=0.18u w=0.36u
.ends

.subckt NAND2 IN1 IN2 OUT
Mp1 OUT IN1 VDD VDD p_18 l=0.18u w=0.72u
Mp2 OUT IN2 VDD VDD p_18 l=0.18u w=0.72u
Mn1 N1 IN1 GND GND n_18 l=0.18u w=0.36u
Mn2 OUT IN2 N1 GND n_18 l=0.18u w=0.36u
.ends

.subckt AND2 IN1 IN2 OUT
Xnand2 IN1 IN2 N1 NAND2
Xinv N1 OUT INV
.ends

.subckt OR2 IN1 IN2 OUT
Xnor2 IN1 IN2 N1 NOR2
Xinv N1 OUT INV
.ends

.subckt TG SN SP IN OUT * SN: NMOS gate, SP: PMOS gate; SP usually = ~SN
Mp1 OUT SP IN VDD p_18 l=0.18u w=0.72u
Mn1 OUT SN IN GND n_18 l=0.18u w=0.36u
.ends

.subckt XOR2 IN1 IN2 OUT
Xinv1 IN1 IN1_INV INV
Xinv2 IN2 IN2_INV INV
Mp1 N1 IN2_INV VDD VDD p_18 l=0.18u w=0.72u
Mp2 OUT IN1 N1 VDD p_18 l=0.18u w=0.72u
Mp3 N2 IN2 VDD VDD p_18 l=0.18u w=0.72u
Mp4 OUT IN1_INV N2 VDD p_18 l=0.18u w=0.72u
Mn1 N3 IN1 GND GND n_18 l=0.18u w=0.36u
Mn2 OUT IN2 N3 GND n_18 l=0.18u w=0.36u
Mn3 N4 IN1_INV GND GND n_18 l=0.18u w=0.36u
Mn4 OUT IN2_INV N4 GND n_18 l=0.18u w=0.36u
.ends

*************************
*** Bit Multiplier ***
*************************
.subckt BIT_MUL IN1 IN2 OUT
Xand IN1 IN2 OUT AND2
.ends

*************************
*** 4-bit Multiplier ***
*************************
.subckt MUL4 W0 W1 W2 W3 IN O0 O1 O2 O3
Xmul1 IN W0 O0 BIT_MUL
Xmul2 IN W1 O1 BIT_MUL
Xmul3 IN W2 O2 BIT_MUL
Xmul4 IN W3 O3 BIT_MUL
.ends

*************************
*** Half-Adder ***
*************************
.subckt HA A B SUM CARRY
Xxor A B SUM XOR2
Xand A B CARRY AND2
.ends

*************************
*** Full-Adder ***
*************************
.subckt FA A B CIN SUM COUT
Xxor1 A B N1 XOR2
Xxor2 N1 CIN SUM XOR2
Xand1 A B N2 AND2
Xand2 N1 CIN N3 AND2
Xor N2 N3 COUT OR2
.ends

*************************
*** 4-bit Carry Look-Ahead Adder ***
*************************
.subckt ADDER4 CIN A0 A1 A2 A3 B0 B1 B2 B3 S0 S1 S2 S3 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xcout G3 P3 C3 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM

.ends

*************************
*** 5-bit Carry Look-Ahead Adder ***
*************************
.subckt ADDER5 CIN A0 A1 A2 A3 A4 B0 B1 B2 B3 B4 S0 S1 S2 S3 S4 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xcout G4 P4 C4 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM

.ends

*************************
*** CLA_CARRY ***
*************************
.subckt CLA_CARRY G P CIN COUT
Xand1 P CIN N1 AND2
Xor1 G N1 COUT OR2
.ends

*************************
*** CLA_SUM ***
*************************
.subckt CLA_SUM A B CIN S
Xxor1 A B N1 XOR2
Xxor2 N1 CIN S XOR2
.ends

*************************
*** 6-bit Adder ***
*************************
.subckt ADDER6 CIN A0 A1 A2 A3 A4 A5 B0 B1 B2 B3 B4 B5 S0 S1 S2 S3 S4 S5 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2
Xg5 A5 B5 G5 AND2
Xp5 A5 B5 P5 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xc5 G4 P4 C4 C5 CLA_CARRY
Xcout G5 P5 C5 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM
Xsum5 A5 B5 C5 S5 CLA_SUM

.ends

*************************
*** 7-bit Adder ***
*************************
.subckt ADDER7 CIN A0 A1 A2 A3 A4 A5 A6 B0 B1 B2 B3 B4 B5 B6 S0 S1 S2 S3 S4 S5 S6 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2
Xg5 A5 B5 G5 AND2
Xp5 A5 B5 P5 XOR2
Xg6 A6 B6 G6 AND2
Xp6 A6 B6 P6 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xc5 G4 P4 C4 C5 CLA_CARRY
Xc6 G5 P5 C5 C6 CLA_CARRY
Xcout G6 P6 C6 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM
Xsum5 A5 B5 C5 S5 CLA_SUM
Xsum6 A6 B6 C6 S6 CLA_SUM

.ends

*************************
*** 8-bit Adder ***
*************************
.subckt ADDER8 CIN A0 A1 A2 A3 A4 A5 A6 A7 B0 B1 B2 B3 B4 B5 B6 B7 S0 S1 S2 S3 S4 S5 S6 S7 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2
Xg5 A5 B5 G5 AND2
Xp5 A5 B5 P5 XOR2
Xg6 A6 B6 G6 AND2
Xp6 A6 B6 P6 XOR2
Xg7 A7 B7 G7 AND2
Xp7 A7 B7 P7 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xc5 G4 P4 C4 C5 CLA_CARRY
Xc6 G5 P5 C5 C6 CLA_CARRY
Xc7 G6 P6 C6 C7 CLA_CARRY
Xcout G7 P7 C7 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM
Xsum5 A5 B5 C5 S5 CLA_SUM
Xsum6 A6 B6 C6 S6 CLA_SUM
Xsum7 A7 B7 C7 S7 CLA_SUM

.ends

*************************
*** 32 of 4 bit Adder Tree ***
.subckt ADDER_TREE32 CIN I10 I11 I12 I13 I20 I21 I22 I23 I30 I31 I32 I33 I40 I41 I42 I43 I50 I51 I52 I53 I60 I61 I62 I63 I70 I71 I72 I73 I80 I81 I82 I83 I90 I91 I92 I93 I100 I101 I102 I103 I110 I111 I112 I113 I120 I121 I122 I123 I130 I131 I132 I133 I140 I141 I142 I143 I150 I151 I152 I153 I160 I161 I162 I163 I170 I171 I172 I173 I180 I181 I182 I183 I190 I191 I192 I193 I200 I201 I202 I203 I210 I211 I212 I213 I220 I221 I222 I223 I230 I231 I232 I233 I240 I241 I242 I243 I250 I251 I252 I253 I260 I261 I262 I263 I270 I271 I272 I273 I280 I281 I282 I283 I290 I291 I292 I293 I300 I301 I302 I303 I310 I311 I312 I313 I320 I321 I322 I323 S0 S1 S2 S3 S4 S5 S6 S7 S8
Xadder41 CIN I10 I11 I12 I13 I20 I21 I22 I23 TP10_1 TP11_1 TP12_1 TP13_1 TP14_1 ADDER4
Xadder42 CIN I30 I31 I32 I33 I40 I41 I42 I43 TP20_1 TP21_1 TP22_1 TP23_1 TP24_1 ADDER4
Xadder43 CIN I50 I51 I52 I53 I60 I61 I62 I63 TP30_1 TP31_1 TP32_1 TP33_1 TP34_1 ADDER4
Xadder44 CIN I70 I71 I72 I73 I80 I81 I82 I83 TP40_1 TP41_1 TP42_1 TP43_1 TP44_1 ADDER4
Xadder45 CIN I90 I91 I92 I93 I100 I101 I102 I103 TP50_1 TP51_1 TP52_1 TP53_1 TP54_1 ADDER4
Xadder46 CIN I110 I111 I112 I113 I120 I121 I122 I123 TP60_1 TP61_1 TP62_1 TP63_1 TP64_1 ADDER4
Xadder47 CIN I130 I131 I132 I133 I140 I141 I142 I143 TP70_1 TP71_1 TP72_1 TP73_1 TP74_1 ADDER4
Xadder48 CIN I150 I151 I152 I153 I160 I161 I162 I163 TP80_1 TP81_1 TP82_1 TP83_1 TP84_1 ADDER4
Xadder49 CIN I170 I171 I172 I173 I180 I181 I182 I183 TP90_1 TP91_1 TP92_1 TP93_1 TP94_1 ADDER4
Xadder410 CIN I190 I191 I192 I193 I200 I201 I202 I203 TP100_1 TP101_1 TP102_1 TP103_1 TP104_1 ADDER4
Xadder411 CIN I210 I211 I212 I213 I220 I221 I222 I223 TP110_1 TP111_1 TP112_1 TP113_1 TP114_1 ADDER4
Xadder412 CIN I230 I231 I232 I233 I240 I241 I242 I243 TP120_1 TP121_1 TP122_1 TP123_1 TP124_1 ADDER4
Xadder413 CIN I250 I251 I252 I253 I260 I261 I262 I263 TP130_1 TP131_1 TP132_1 TP133_1 TP134_1 ADDER4
Xadder414 CIN I270 I271 I272 I273 I280 I281 I282 I283 TP140_1 TP141_1 TP142_1 TP143_1 TP144_1 ADDER4
Xadder415 CIN I290 I291 I292 I293 I300 I301 I302 I303 TP150_1 TP151_1 TP152_1 TP153_1 TP154_1 ADDER4
Xadder416 CIN I310 I311 I312 I313 I320 I321 I322 I323 TP160_1 TP161_1 TP162_1 TP163_1 TP164_1 ADDER4
Xadder51 CIN TP10_1 TP11_1 TP12_1 TP13_1 TP14_1 TP20_1 TP21_1 TP22_1 TP23_1 TP24_1 TP10_2 TP11_2 TP12_2 TP13_2 TP14_2 TP15_2 ADDER5
Xadder52 CIN TP30_1 TP31_1 TP32_1 TP33_1 TP34_1 TP40_1 TP41_1 TP42_1 TP43_1 TP44_1 TP20_2 TP21_2 TP22_2 TP23_2 TP24_2 TP25_2 ADDER5
Xadder53 CIN TP50_1 TP51_1 TP52_1 TP53_1 TP54_1 TP60_1 TP61_1 TP62_1 TP63_1 TP64_1 TP30_2 TP31_2 TP32_2 TP33_2 TP34_2 TP35_2 ADDER5
Xadder54 CIN TP70_1 TP71_1 TP72_1 TP73_1 TP74_1 TP80_1 TP81_1 TP82_1 TP83_1 TP84_1 TP40_2 TP41_2 TP42_2 TP43_2 TP44_2 TP45_2 ADDER5
Xadder55 CIN TP90_1 TP91_1 TP92_1 TP93_1 TP94_1 TP100_1 TP101_1 TP102_1 TP103_1 TP104_1 TP50_2 TP51_2 TP52_2 TP53_2 TP54_2 TP55_2 ADDER5
Xadder56 CIN TP110_1 TP111_1 TP112_1 TP113_1 TP114_1 TP120_1 TP121_1 TP122_1 TP123_1 TP124_1 TP60_2 TP61_2 TP62_2 TP63_2 TP64_2 TP65_2 ADDER5
Xadder57 CIN TP130_1 TP131_1 TP132_1 TP133_1 TP134_1 TP140_1 TP141_1 TP142_1 TP143_1 TP144_1 TP70_2 TP71_2 TP72_2 TP73_2 TP74_2 TP75_2 ADDER5
Xadder58 CIN TP150_1 TP151_1 TP152_1 TP153_1 TP154_1 TP160_1 TP161_1 TP162_1 TP163_1 TP164_1 TP80_2 TP81_2 TP82_2 TP83_2 TP84_2 TP85_2 ADDER5
Xadder61 CIN TP10_2 TP11_2 TP12_2 TP13_2 TP14_2 TP15_2 TP20_2 TP21_2 TP22_2 TP23_2 TP24_2 TP25_2 TP10_3 TP11_3 TP12_3 TP13_3 TP14_3 TP15_3 TP16_3 ADDER6
Xadder62 CIN TP30_2 TP31_2 TP32_2 TP33_2 TP34_2 TP35_2 TP40_2 TP41_2 TP42_2 TP43_2 TP44_2 TP45_2 TP20_3 TP21_3 TP22_3 TP23_3 TP24_3 TP25_3 TP26_3 ADDER6
Xadder63 CIN TP50_2 TP51_2 TP52_2 TP53_2 TP54_2 TP55_2 TP60_2 TP61_2 TP62_2 TP63_2 TP64_2 TP65_2 TP30_3 TP31_3 TP32_3 TP33_3 TP34_3 TP35_3 TP36_3 ADDER6
Xadder64 CIN TP70_2 TP71_2 TP72_2 TP73_2 TP74_2 TP75_2 TP80_2 TP81_2 TP82_2 TP83_2 TP84_2 TP85_2 TP40_3 TP41_3 TP42_3 TP43_3 TP44_3 TP45_3 TP46_3 ADDER6
Xadder71 CIN TP10_3 TP11_3 TP12_3 TP13_3 TP14_3 TP15_3 TP16_3 TP20_3 TP21_3 TP22_3 TP23_3 TP24_3 TP25_3 TP26_3 TP10_4 TP11_4 TP12_4 TP13_4 TP14_4 TP15_4 TP16_4 TP17_4 ADDER7
Xadder72 CIN TP30_3 TP31_3 TP32_3 TP33_3 TP34_3 TP35_3 TP36_3 TP40_3 TP41_3 TP42_3 TP43_3 TP44_3 TP45_3 TP46_3 TP20_4 TP21_4 TP22_4 TP23_4 TP24_4 TP25_4 TP26_4 TP27_4 ADDER7
Xadder81 CIN TP10_4 TP11_4 TP12_4 TP13_4 TP14_4 TP15_4 TP16_4 TP17_4 TP20_4 TP21_4 TP22_4 TP23_4 TP24_4 TP25_4 TP26_4 TP27_4 S0 S1 S2 S3 S4 S5 S6 S7 S8 ADDER8
.ends

*************************
*** Latch ***
.subckt LATCH W
Xinv1 TMP W INV
Xinv2 W TMP INV
.ends

*************************
*** Compute Cell 32 * 4 bit***
.subckt COMPUTE I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 I13 I14 I15 I16 I17 I18 I19 I20 I21 I22 I23 I24 I25 I26 I27 I28 I29 I30 I31 I32 S0 S1 S2 S3 S4 S5 S6 S7 S8
Xlatch1_0 W10 LATCH
Xlatch1_1 W11 LATCH
Xlatch1_2 W12 LATCH
Xlatch1_3 W13 LATCH
Xlatch2_0 W20 LATCH
Xlatch2_1 W21 LATCH
Xlatch2_2 W22 LATCH
Xlatch2_3 W23 LATCH
Xlatch3_0 W30 LATCH
Xlatch3_1 W31 LATCH
Xlatch3_2 W32 LATCH
Xlatch3_3 W33 LATCH
Xlatch4_0 W40 LATCH
Xlatch4_1 W41 LATCH
Xlatch4_2 W42 LATCH
Xlatch4_3 W43 LATCH
Xlatch5_0 W50 LATCH
Xlatch5_1 W51 LATCH
Xlatch5_2 W52 LATCH
Xlatch5_3 W53 LATCH
Xlatch6_0 W60 LATCH
Xlatch6_1 W61 LATCH
Xlatch6_2 W62 LATCH
Xlatch6_3 W63 LATCH
Xlatch7_0 W70 LATCH
Xlatch7_1 W71 LATCH
Xlatch7_2 W72 LATCH
Xlatch7_3 W73 LATCH
Xlatch8_0 W80 LATCH
Xlatch8_1 W81 LATCH
Xlatch8_2 W82 LATCH
Xlatch8_3 W83 LATCH
Xlatch9_0 W90 LATCH
Xlatch9_1 W91 LATCH
Xlatch9_2 W92 LATCH
Xlatch9_3 W93 LATCH
Xlatch10_0 W100 LATCH
Xlatch10_1 W101 LATCH
Xlatch10_2 W102 LATCH
Xlatch10_3 W103 LATCH
Xlatch11_0 W110 LATCH
Xlatch11_1 W111 LATCH
Xlatch11_2 W112 LATCH
Xlatch11_3 W113 LATCH
Xlatch12_0 W120 LATCH
Xlatch12_1 W121 LATCH
Xlatch12_2 W122 LATCH
Xlatch12_3 W123 LATCH
Xlatch13_0 W130 LATCH
Xlatch13_1 W131 LATCH
Xlatch13_2 W132 LATCH
Xlatch13_3 W133 LATCH
Xlatch14_0 W140 LATCH
Xlatch14_1 W141 LATCH
Xlatch14_2 W142 LATCH
Xlatch14_3 W143 LATCH
Xlatch15_0 W150 LATCH
Xlatch15_1 W151 LATCH
Xlatch15_2 W152 LATCH
Xlatch15_3 W153 LATCH
Xlatch16_0 W160 LATCH
Xlatch16_1 W161 LATCH
Xlatch16_2 W162 LATCH
Xlatch16_3 W163 LATCH
Xlatch17_0 W170 LATCH
Xlatch17_1 W171 LATCH
Xlatch17_2 W172 LATCH
Xlatch17_3 W173 LATCH
Xlatch18_0 W180 LATCH
Xlatch18_1 W181 LATCH
Xlatch18_2 W182 LATCH
Xlatch18_3 W183 LATCH
Xlatch19_0 W190 LATCH
Xlatch19_1 W191 LATCH
Xlatch19_2 W192 LATCH
Xlatch19_3 W193 LATCH
Xlatch20_0 W200 LATCH
Xlatch20_1 W201 LATCH
Xlatch20_2 W202 LATCH
Xlatch20_3 W203 LATCH
Xlatch21_0 W210 LATCH
Xlatch21_1 W211 LATCH
Xlatch21_2 W212 LATCH
Xlatch21_3 W213 LATCH
Xlatch22_0 W220 LATCH
Xlatch22_1 W221 LATCH
Xlatch22_2 W222 LATCH
Xlatch22_3 W223 LATCH
Xlatch23_0 W230 LATCH
Xlatch23_1 W231 LATCH
Xlatch23_2 W232 LATCH
Xlatch23_3 W233 LATCH
Xlatch24_0 W240 LATCH
Xlatch24_1 W241 LATCH
Xlatch24_2 W242 LATCH
Xlatch24_3 W243 LATCH
Xlatch25_0 W250 LATCH
Xlatch25_1 W251 LATCH
Xlatch25_2 W252 LATCH
Xlatch25_3 W253 LATCH
Xlatch26_0 W260 LATCH
Xlatch26_1 W261 LATCH
Xlatch26_2 W262 LATCH
Xlatch26_3 W263 LATCH
Xlatch27_0 W270 LATCH
Xlatch27_1 W271 LATCH
Xlatch27_2 W272 LATCH
Xlatch27_3 W273 LATCH
Xlatch28_0 W280 LATCH
Xlatch28_1 W281 LATCH
Xlatch28_2 W282 LATCH
Xlatch28_3 W283 LATCH
Xlatch29_0 W290 LATCH
Xlatch29_1 W291 LATCH
Xlatch29_2 W292 LATCH
Xlatch29_3 W293 LATCH
Xlatch30_0 W300 LATCH
Xlatch30_1 W301 LATCH
Xlatch30_2 W302 LATCH
Xlatch30_3 W303 LATCH
Xlatch31_0 W310 LATCH
Xlatch31_1 W311 LATCH
Xlatch31_2 W312 LATCH
Xlatch31_3 W313 LATCH
Xlatch32_0 W320 LATCH
Xlatch32_1 W321 LATCH
Xlatch32_2 W322 LATCH
Xlatch32_3 W323 LATCH
Xmul41 W10 W11 W12 W13 I1 O10 O11 O12 O13 MUL4
Xmul42 W20 W21 W22 W23 I2 O20 O21 O22 O23 MUL4
Xmul43 W30 W31 W32 W33 I3 O30 O31 O32 O33 MUL4
Xmul44 W40 W41 W42 W43 I4 O40 O41 O42 O43 MUL4
Xmul45 W50 W51 W52 W53 I5 O50 O51 O52 O53 MUL4
Xmul46 W60 W61 W62 W63 I6 O60 O61 O62 O63 MUL4
Xmul47 W70 W71 W72 W73 I7 O70 O71 O72 O73 MUL4
Xmul48 W80 W81 W82 W83 I8 O80 O81 O82 O83 MUL4
Xmul49 W90 W91 W92 W93 I9 O90 O91 O92 O93 MUL4
Xmul410 W100 W101 W102 W103 I10 O100 O101 O102 O103 MUL4
Xmul411 W110 W111 W112 W113 I11 O110 O111 O112 O113 MUL4
Xmul412 W120 W121 W122 W123 I12 O120 O121 O122 O123 MUL4
Xmul413 W130 W131 W132 W133 I13 O130 O131 O132 O133 MUL4
Xmul414 W140 W141 W142 W143 I14 O140 O141 O142 O143 MUL4
Xmul415 W150 W151 W152 W153 I15 O150 O151 O152 O153 MUL4
Xmul416 W160 W161 W162 W163 I16 O160 O161 O162 O163 MUL4
Xmul417 W170 W171 W172 W173 I17 O170 O171 O172 O173 MUL4
Xmul418 W180 W181 W182 W183 I18 O180 O181 O182 O183 MUL4
Xmul419 W190 W191 W192 W193 I19 O190 O191 O192 O193 MUL4
Xmul420 W200 W201 W202 W203 I20 O200 O201 O202 O203 MUL4
Xmul421 W210 W211 W212 W213 I21 O210 O211 O212 O213 MUL4
Xmul422 W220 W221 W222 W223 I22 O220 O221 O222 O223 MUL4
Xmul423 W230 W231 W232 W233 I23 O230 O231 O232 O233 MUL4
Xmul424 W240 W241 W242 W243 I24 O240 O241 O242 O243 MUL4
Xmul425 W250 W251 W252 W253 I25 O250 O251 O252 O253 MUL4
Xmul426 W260 W261 W262 W263 I26 O260 O261 O262 O263 MUL4
Xmul427 W270 W271 W272 W273 I27 O270 O271 O272 O273 MUL4
Xmul428 W280 W281 W282 W283 I28 O280 O281 O282 O283 MUL4
Xmul429 W290 W291 W292 W293 I29 O290 O291 O292 O293 MUL4
Xmul430 W300 W301 W302 W303 I30 O300 O301 O302 O303 MUL4
Xmul431 W310 W311 W312 W313 I31 O310 O311 O312 O313 MUL4
Xmul432 W320 W321 W322 W323 I32 O320 O321 O322 O323 MUL4
Xadder_1 GND O10 O11 O12 O13 O20 O21 O22 O23 O30 O31 O32 O33 O40 O41 O42 O43 O50 O51 O52 O53 O60 O61 O62 O63 O70 O71 O72 O73 O80 O81 O82 O83 O90 O91 O92 O93 O100 O101 O102 O103 O110 O111 O112 O113 O120 O121 O122 O123 O130 O131 O132 O133 O140 O141 O142 O143 O150 O151 O152 O153 O160 O161 O162 O163 O170 O171 O172 O173 O180 O181 O182 O183 O190 O191 O192 O193 O200 O201 O202 O203 O210 O211 O212 O213 O220 O221 O222 O223 O230 O231 O232 O233 O240 O241 O242 O243 O250 O251 O252 O253 O260 O261 O262 O263 O270 O271 O272 O273 O280 O281 O282 O283 O290 O291 O292 O293 O300 O301 O302 O303 O310 O311 O312 O313 O320 O321 O322 O323 S0 S1 S2 S3 S4 S5 S6 S7 S8 ADDER_TREE32
.ends

*************************
*** 9-bit Carry Look-Ahead Adder ***
*************************
.subckt ADDER9 CIN A0 A1 A2 A3 A4 A5 A6 A7 A8 B0 B1 B2 B3 B4 B5 B6 B7 B8 S0 S1 S2 S3 S4 S5 S6 S7 S8 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2
Xg5 A5 B5 G5 AND2
Xp5 A5 B5 P5 XOR2
Xg6 A6 B6 G6 AND2
Xp6 A6 B6 P6 XOR2
Xg7 A7 B7 G7 AND2
Xp7 A7 B7 P7 XOR2
Xg8 A8 B8 G8 AND2
Xp8 A8 B8 P8 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xc5 G4 P4 C4 C5 CLA_CARRY
Xc6 G5 P5 C5 C6 CLA_CARRY
Xc7 G6 P6 C6 C7 CLA_CARRY
Xc8 G7 P7 C7 C8 CLA_CARRY
Xcout G8 P8 C8 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM
Xsum5 A5 B5 C5 S5 CLA_SUM
Xsum6 A6 B6 C6 S6 CLA_SUM
Xsum7 A7 B7 C7 S7 CLA_SUM
Xsum8 A8 B8 C8 S8 CLA_SUM

.ends

*************************
*** 12-bit Carry Look-Ahead Adder ***
*************************
.subckt ADDER12 CIN A0 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 S0 S1 S2 S3 S4 S5 S6 S7 S8 S9 S10 S11 COUT

* Generate (G) and Propagate (P) logic
Xg0 A0 B0 G0 AND2
Xp0 A0 B0 P0 XOR2
Xg1 A1 B1 G1 AND2
Xp1 A1 B1 P1 XOR2
Xg2 A2 B2 G2 AND2
Xp2 A2 B2 P2 XOR2
Xg3 A3 B3 G3 AND2
Xp3 A3 B3 P3 XOR2
Xg4 A4 B4 G4 AND2
Xp4 A4 B4 P4 XOR2
Xg5 A5 B5 G5 AND2
Xp5 A5 B5 P5 XOR2
Xg6 A6 B6 G6 AND2
Xp6 A6 B6 P6 XOR2
Xg7 A7 B7 G7 AND2
Xp7 A7 B7 P7 XOR2
Xg8 A8 B8 G8 AND2
Xp8 A8 B8 P8 XOR2
Xg9 A9 B9 G9 AND2
Xp9 A9 B9 P9 XOR2
Xg10 A10 B10 G10 AND2
Xp10 A10 B10 P10 XOR2
Xg11 A11 B11 G11 AND2
Xp11 A11 B11 P11 XOR2

* Carry calculation
Xc1 G0 P0 CIN C1 CLA_CARRY
Xc2 G1 P1 C1 C2 CLA_CARRY
Xc3 G2 P2 C2 C3 CLA_CARRY
Xc4 G3 P3 C3 C4 CLA_CARRY
Xc5 G4 P4 C4 C5 CLA_CARRY
Xc6 G5 P5 C5 C6 CLA_CARRY
Xc7 G6 P6 C6 C7 CLA_CARRY
Xc8 G7 P7 C7 C8 CLA_CARRY
Xc9 G8 P8 C8 C9 CLA_CARRY
Xc10 G9 P9 C9 C10 CLA_CARRY
Xc11 G10 P10 C10 C11 CLA_CARRY
Xcout G11 P11 C11 COUT CLA_CARRY

* Sum logic
Xsum0 A0 B0 CIN S0 CLA_SUM
Xsum1 A1 B1 C1 S1 CLA_SUM
Xsum2 A2 B2 C2 S2 CLA_SUM
Xsum3 A3 B3 C3 S3 CLA_SUM
Xsum4 A4 B4 C4 S4 CLA_SUM
Xsum5 A5 B5 C5 S5 CLA_SUM
Xsum6 A6 B6 C6 S6 CLA_SUM
Xsum7 A7 B7 C7 S7 CLA_SUM
Xsum8 A8 B8 C8 S8 CLA_SUM
Xsum9 A9 B9 C9 S9 CLA_SUM
Xsum10 A10 B10 C10 S10 CLA_SUM
Xsum11 A11 B11 C11 S11 CLA_SUM

.ends

*************************
*** D latch ***
.subckt DLATCH D ENB Q Q_INV
Xinv D D_INV INV
Xnand21 D ENB N1 NAND2
Xnand22 D_INV ENB N2 NAND2
Xnand23 N1 Q_INV Q NAND2
Xnand24 N2 Q Q_INV NAND2
.ends

*************************
*** D flip-flop ***
*************************
.subckt DFF DI CLK RST Q Q_INV
Xand1 DI RST D AND2
Xinv1 CLK CLK_INV INV
Mn1 N1 CLK_INV D GND n_18 l=0.18u w=0.36u
Xnand1 N1 VDD N2 NAND2
Xinv2 N2 N3 INV
Mn2 N1 CLK N3 GND n_18 l=0.18u w=0.36u
Mn3 N4 CLK N2 GND n_18 l=0.18u w=0.36u
Xinv3 N4 Q INV
Xnand2 Q VDD Q_INV NAND2
Mn4 N4 CLK_INV Q_INV GND n_18 l=0.18u w=0.36u
.ends

*************************
*** 13-bit Register ***
*************************
.subckt REG13 I0 I1 I2 I3 I4 I5 I6 I7 I8 I9 I10 I11 I12 CLK ENB O0 O1 O2 O3 O4 O5 O6 O7 O8 O9 O10 O11 O12
Xdff1 I0 CLK ENB O0 O0_INV DFF
Xdff2 I1 CLK ENB O1 O1_INV DFF
Xdff3 I2 CLK ENB O2 O2_INV DFF
Xdff4 I3 CLK ENB O3 O3_INV DFF
Xdff5 I4 CLK ENB O4 O4_INV DFF
Xdff6 I5 CLK ENB O5 O5_INV DFF
Xdff7 I6 CLK ENB O6 O6_INV DFF
Xdff8 I7 CLK ENB O7 O7_INV DFF
Xdff9 I8 CLK ENB O8 O8_INV DFF
Xdff10 I9 CLK ENB O9 O9_INV DFF
Xdff11 I10 CLK ENB O10 O10_INV DFF
Xdff12 I11 CLK ENB O11 O11_INV DFF
Xdff13 I12 CLK ENB O12 O12_INV DFF
.ends
